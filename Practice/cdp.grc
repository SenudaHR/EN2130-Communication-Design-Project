options:
  parameters:
    author: BellLabz
    category: Custom
    description: cdp project
    generate_options: qt_gui
    id: cdp
    output_language: python
    title: cdp
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: cc_dec
  id: variable_cc_decoder_def
  parameters:
    dim1: '1'
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '1'
    padding: 'True'
    polys: polys
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: cc_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'True'
    polys: polys
    rate: '2'
    state_start: '0'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '42'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2e9
    step: 100e3
    stop: 6e9
    value: 2.4e9
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF gain
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rf_gain_sink
  id: variable_qtgui_range
  parameters:
    label: RF gain sink
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_freq_
  id: variable
  parameters:
    comment: Set rx frequency
    value: 433e6
  states: {}
- name: rxbw
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: tx_freq
  id: variable
  parameters:
    comment: Set tx frequency
    value: 600e6
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: txgain
  id: variable_qtgui_range
  parameters:
    start: '18'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: ''
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: 3+2j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend an address byte to a PDU payload
          """
          def __init__(self, address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              self.address = address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  # prepend address
                  data.insert(0, self.address)
                  out_msg = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern("out"), out_msg)
    address: '15'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend an address byte to a PDU payload
          """
          def __init__(self, address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              self.address = address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  # prepend address
                  data.insert(0, self.address)
                  out_msg = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern("out"), out_msg)
    address: '50'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU to UTF-8 Text File Writer
          - Overwrites at start of simulation
          - Writes only payloads (clean UTF-8)
          - Appends for subsequent PDUs
          """

          def __init__(self, file_path="output.txt"):
              gr.basic_block.__init__(
                  self,
                  name="PDU to File Writer",
                  in_sig=[],
                  out_sig=[]
              )
              self.file_path = file_path
              self.first_write = True  # ensures overwrite once
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self._write)

          def _write(self, msg):
              if not pmt.is_pair(msg):
                  return
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return

              # Extract bytes
              data = bytearray(pmt.u8vector_elements(vec))
              try:
                  # Safely decode as UTF-8
                  text = data.decode("utf-8", errors="ignore")

                  # Overwrite first time, then append
                  mode = "w" if self.first_write else "a"
                  with open(self.file_path, mode, encoding="utf-8") as f:
                      f.write(text)

                  self.first_write = False
                  print(f"[TextFile] Wrote {len(text)} chars to {self.file_path}")

              except Exception as e:
                  print(f"[TextFile] Error writing: {e}")
    file_path: r"D:\University\Semester 3\EN2130\gnupractice\rx.txt"
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      import threading
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Custom block: File reader -> PDU sender with retransmission control.
          - Splits file into packets (1 byte for ID, rest for payload)
          - Sends packets as PDUs
          - Waits for ACKs [0xAA, packet_id]
          - Retransmits until ACK received or retry limit exceeded
          """

          def __init__(self, filepath="", wait_time=2.0, pkt_size=32):
              gr.basic_block.__init__(
                  self,
                  name="File to PDU with ARQ",
                  in_sig=[],
                  out_sig=[]
              )

              # Parameters
              self._filepath = filepath
              self._timeout = float(wait_time)
              self._pkt_size = int(pkt_size)

              # Message ports
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_in(pmt.intern("ack_in"))
              self.set_msg_handler(pmt.intern("ack_in"), self._process_ack)

              # Thread + synchronization
              self._thread = threading.Thread(target=self._run)
              self._thread.daemon = True
              self._stop_event = threading.Event()
              self._ack_event = threading.Event()
              self._lock = threading.Lock()

              self._waiting_for = None  # Expected ACK packet ID

          def start(self):
              self._stop_event.clear()
              self._thread.start()
              return super().start()

          def stop(self):
              self._stop_event.set()
              self._ack_event.set()   # unblock wait
              self._thread.join()
              return super().stop()

          # ---------------------------
          # Sending loop
          # ---------------------------
          def _run(self):
              try:
                  with open(self._filepath, "rb") as fh:
                      raw = fh.read()
              except OSError as e:
                  print(f"[FilePDU] Could not open file: {e}")
                  return

              # Create chunks (reserve 1 byte for sequence ID)
              chunks = []
              step = self._pkt_size - 1
              for i in range(0, len(raw), step):
                  chunks.append(raw[i:i+step])

              seq_id = 1  # 0x01..0xFF (avoid 0x00)

              for block in chunks:
                  if self._stop_event.is_set():
                      break

                  packet = bytes([seq_id]) + block
                  vec = pmt.init_u8vector(len(packet), list(packet))
                  pdu = pmt.cons(pmt.PMT_NIL, vec)

                  # Update expected ACK
                  with self._lock:
                      self._waiting_for = seq_id
                      self._ack_event.clear()

                  attempts = 0
                  limit = 100

                  while not self._stop_event.is_set() and attempts < limit:
                      self.message_port_pub(pmt.intern("out"), pdu)
                      print(f"[FilePDU] Packet 0x{seq_id:02X} sent (try {attempts+1})")

                      if self._ack_event.wait(timeout=self._timeout):
                          # ACK arrived
                          break
                      else:
                          print(f"[FilePDU] Timeout waiting for ACK of 0x{seq_id:02X}, retrying...")
                          attempts += 1

                  if attempts >= limit:
                      print(f"[FilePDU] Failed: no ACK for packet 0x{seq_id:02X} after {limit} tries")
                      self._stop_event.set()
                      return

                  # Increment sequence ID (avoid zero)
                  seq_id = (seq_id + 1) & 0xFF
                  if seq_id == 0:
                      seq_id = 1

          # ---------------------------
          # ACK Handler
          # ---------------------------
          def _process_ack(self, msg):
              try:
                  payload = pmt.cdr(msg)

                  if not pmt.is_u8vector(payload):
                      print("[FilePDU] Invalid ACK format (not u8vector)")
                      return

                  arr = bytearray(pmt.u8vector_elements(payload))
                  if len(arr) < 2:
                      print("[FilePDU] ACK too short")
                      return

                  if arr[0] != 0xAA:
                      print("[FilePDU] Bad ACK header")
                      return

                  ack_id = arr[1]

                  with self._lock:
                      if ack_id == self._waiting_for:
                          print(f"[FilePDU] ACK received for packet 0x{ack_id:02X}")
                          self._ack_event.set()

              except Exception as e:
                  print(f"[FilePDU] Error processing ACK: {e}")
    filepath: r"D:\University\Semester 3\EN2130\gnupractice\ab.txt"
    pkt_size: '32'
    wait_time: '0.1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '15'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '50'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      import zlib
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          CRC32 Checker + Dedup + Forwarder
          - Input : [pkt_id | payload | crc32]
          - Output: [payload only] if CRC valid and not duplicate
          - Still sends ACKs for valid packets
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="CRC32 Dedup + Forwarder",
                  in_sig=[],
                  out_sig=[]
              )

              self.received_ids = set()  # track processed packet IDs

              # Ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))  # forward payload
              self.message_port_register_out(pmt.intern("ack_out"))  # ACKs

              self.set_msg_handler(pmt.intern("in"), self._handle_msg)

          def _handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return

              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) < 5:
                  print("[CRC32] Frame too short")
                  return

              pkt_id = data[0]
              payload = data[1:-4]
              recv_crc = int.from_bytes(data[-4:], "big")
              calc_crc = zlib.crc32(bytes([pkt_id]) + payload) & 0xFFFFFFFF

              if calc_crc != recv_crc:
                  print(f"[CRC32] FAIL (Packet {pkt_id})")
                  return

              # ✅ CRC OK
              print(f"[CRC32] OK (Packet {pkt_id})")

              # Send ACK for all valid packets
              ack_bytes = bytes([0xAA, pkt_id])
              ack_vec = pmt.init_u8vector(len(ack_bytes), list(ack_bytes))
              ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)
              self.message_port_pub(pmt.intern("ack_out"), ack_pdu)

              # Forward payload only if packet_id not already processed
              if pkt_id not in self.received_ids:
                  self.received_ids.add(pkt_id)
                  try:
                      text = payload.decode("utf-8", errors="ignore")
                      clean_bytes = text.encode("utf-8")
                      out_vec = pmt.init_u8vector(len(clean_bytes), list(clean_bytes))
                      out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
                      self.message_port_pub(pmt.intern("out"), out_msg)
                      print(f"[Forward] Packet {pkt_id} → {len(clean_bytes)} bytes forwarded")
                  except Exception as e:
                      print(f"[Forward] UTF-8 decode error: {e}")
              else:
                  print(f"[Forward] Packet {pkt_id} duplicate, not forwarded")
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad

      class aes_encrypt(gr.basic_block):
          """
          AES Encryption Block
          - Encrypts PDUs using AES-128-CBC
          - Key & IV fixed for demo (replace with secure exchange in real systems)
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Encrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  enc_data = cipher.encrypt(pad(data, AES.block_size))

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(enc_data), list(enc_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,2,2,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: Frequency Spectrum of Tx ACK
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum of ACK
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX-SPECTRUM
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    name: RX-SPECTRUM of ACK
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      def tag():
          import os
          global content
          detected = False
          typs = [b'mp3', b'jpeg', b'mp4', b'ts']

          print("[INFO] Waiting for received file type...")

          while not detected:
              try:
                  with open('./rx.tmp', 'rb') as file:
                      content = file.read()
              except FileNotFoundError:
                  print("[WARN] rx.tmp not found yet...")
                  time.sleep(1)
                  continue

              for tag in typs:
                  position = content.rfind(tag)
                  if position != -1:
                      remove_preamble('./rx.tmp')
                      filename = {
                          b'jpeg': "out.jpg",
                          b'mp3': "out.mp3",
                          b'mp4': "out.mp4",
                          b'ts': "out.ts"
                      }[tag]

                      with open(filename, 'wb') as f:
                          f.write(content)

                      print(f"[OK] Detected file type: {tag.decode()} -> saved as {filename}")

                      # Cross-platform open
                      if sys.platform.startswith("darwin"):  # macOS
                          subprocess.run(["open", filename])
                      elif sys.platform.startswith("linux"):
                          subprocess.run(["xdg-open", filename])
                      elif sys.platform.startswith("win"):
                          os.startfile(filename)

                      detected = True
                      break

              if not detected:
                  print("[INFO] No file type found yet, retrying...")
                  time.sleep(1)
    section: main_after_stop
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: freq/2
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: rxbw
    center_freq: freq
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: rxbw
    center_freq: freq/2
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, epy_block_5, in]
- [digital_crc_append_0_0, out, epy_block_0_0, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_0_0, out, digital_protocol_formatter_async_0_0, in]
- [epy_block_2, out, digital_crc_append_0, in]
- [epy_block_3, out, epy_block_6, in]
- [epy_block_3_0, out, epy_block_2, ack_in]
- [epy_block_4, ack_out, digital_crc_append_0_0, in]
- [epy_block_4, out, epy_block_1, in]
- [epy_block_5, out, epy_block_0, in]
- [epy_block_6, out, epy_block_4, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
