options:
  parameters:
    author: BellLabz
    category: Custom
    description: cdp project
    generate_options: qt_gui
    id: cdp
    output_language: python
    title: cdp
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: ''
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '32'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend an address byte to a PDU payload
          """
          def __init__(self, address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              self.address = address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  # prepend address
                  data.insert(0, self.address)
                  out_msg = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern("out"), out_msg)
    address: '15'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend an address byte to a PDU payload
          """
          def __init__(self, address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              self.address = address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  # prepend address
                  data.insert(0, self.address)
                  out_msg = pmt.cons(meta, pmt.init_u8vector(len(data), data))
                  self.message_port_pub(pmt.intern("out"), out_msg)
    address: '50'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\n\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\n\nclass blk(gr.basic_block):\n    \"\"\"\n    Messenger-style GUI block with wallpaper background.\n    Bubbles auto-adjust height to fit content (both sent and received).\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(\n            self,\n            name=\"Messenger GUI\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.bg_image = bg_image\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.receive_message)\n\n        # Ensure QApplication exists\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        # Main widget\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Messenger GUI\")\n        self.qt_widget.resize(600, 500)\n\n        main_layout = QtWidgets.QVBoxLayout()\n        main_layout.setContentsMargins(0, 0, 0, 0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Scroll area with wallpaper\n        self.scroll_area = WallpaperScrollArea(bg_image=self.bg_image)\n        self.scroll_area.setStyleSheet(\"border: none;\")\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Chat container\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n\n        # Input area\n        input_layout = QtWidgets.QHBoxLayout()\n        self.input_box = QtWidgets.QLineEdit()\n        self.input_box.setPlaceholderText(\"Type a message...\")\n        self.input_box.setStyleSheet(\"\"\"\n            QLineEdit {\n                border-radius: 15px;\n                padding: 12px;\n                background-color: rgba(255,255,255,230);\n                font-size: 32px;\n            }\n        \"\"\")\n        self.send_button = QtWidgets.QPushButton(\"Send\")\n        self.send_button.setStyleSheet(\"\"\"\n            QPushButton {\n                background-color: #4CAF50;\n                color: white;\n                border-radius: 15px;\n                padding: 12px 24px;\n                font-weight: bold;\n                font-size: 32px;\n            }\n            QPushButton:hover {\n                background-color: #45a049;\n            }\n        \"\"\")\n        input_layout.addWidget(self.input_box)\n        input_layout.addWidget(self.send_button)\n        main_layout.addLayout(input_layout)\n\n        # Connect signals\n        self.send_button.clicked.connect(self.send_message)\n        self.input_box.returnPressed.connect(self.send_message)\n\n        # Show widget\n        self.qt_widget.show()\n\n    def create_bubble(self, text, sent=True):\n        \"\"\"\n        Create a QLabel bubble that auto-adjusts height for wrapped text.\n        \"\"\"\n        label = QtWidgets.QLabel(text)\n        label.setWordWrap(True)\n        label.setTextInteractionFlags(QtCore.Qt.TextSelectableByMouse)\n        label.setMaximumWidth(500)\n        label.setStyleSheet(f\"\"\"\n            QLabel {{\n                background-color: {'#4CAF50' if sent else '#2196F3'};\n                color: white;\n                border-radius: 15px;\n                padding: 15px;\n                font-size: 32px;\n            }}\n        \"\"\")\n        # Let layout expand height automatically\n        label.setSizePolicy(QtWidgets.QSizePolicy.Preferred, QtWidgets.QSizePolicy.MinimumExpanding)\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0, 0, 0, 100))\n        label.setGraphicsEffect(effect)\n\n        # Wrap in container for alignment\n        container = QtWidgets.QWidget()\n        layout = QtWidgets.QVBoxLayout()\n        layout.setContentsMargins(0, 0, 0, 0)\n        layout.addWidget(label)\n        layout.setAlignment(QtCore.Qt.AlignRight if sent else QtCore.Qt.AlignLeft)\n        container.setLayout(layout)\n\n        self.chat_layout.addWidget(container)\n        QtCore.QTimer.singleShot(50, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n    def send_message(self):\n        text = self.input_box.text().strip()\n        if not text:\n            return\n\n        self.message_port_pub(pmt.intern(\"out\"), pmt.string_to_symbol(text))\n        self.create_bubble(text, sent=True)\n        self.input_box.clear()\n\n    def receive_message(self, msg):\n        if not pmt.is_symbol(msg):\n            return\n        text = pmt.symbol_to_string(msg)\n        self.create_bubble(text, sent=False)\n\n"
    bg_image: '''/home/ravindu/Downloads/pexels-pixabay-263402(1).jpg'''
  states: {state: disabled}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\n\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\n\nclass blk(gr.basic_block):\n    \"\"\"\n    WhatsApp-style Messenger GUI with scalable wallpaper,\n    horizontally expanding bubbles, fully displayed text,\n    2x larger font, and string-type PDU output.\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(\n            self,\n            name=\"Messenger GUI\",\n            in_sig=None,\n            out_sig=None,\n        )\n\n        self.bg_image = bg_image\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # ✅ Ensure QApplication exists (works even if no other Qt blocks in GRC)\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        # Main widget\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Messenger GUI\")\n        self.qt_widget.resize(600, 500)\n\n        main_layout = QtWidgets.QVBoxLayout()\n        main_layout.setContentsMargins(0, 0, 0, 0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Scroll area with wallpaper\n        self.scroll_area = WallpaperScrollArea(bg_image=self.bg_image)\n        self.scroll_area.setStyleSheet(\"border: none;\")\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Chat container\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n\n        # Input area\n        input_layout = QtWidgets.QHBoxLayout()\n        self.input_box = QtWidgets.QLineEdit()\n        self.input_box.setPlaceholderText(\"Type a message...\")\n        self.input_box.setStyleSheet(\"\"\"\n            QLineEdit {\n                border-radius: 15px;\n                padding: 12px;\n                background-color: rgba(255,255,255,230);\n                font-size: 32px;\n            }\n        \"\"\")\n        self.send_button = QtWidgets.QPushButton(\"Send\")\n        self.send_button.setStyleSheet(\"\"\"\n            QPushButton {\n                background-color: #4CAF50;\n                color: white;\n                border-radius: 15px;\n                padding: 12px 24px;\n                font-weight: bold;\n                font-size: 32px;\n            }\n            QPushButton:hover {\n                background-color: #45a049;\n            }\n        \"\"\")\n        input_layout.addWidget(self.input_box)\n        input_layout.addWidget(self.send_button)\n        main_layout.addLayout(input_layout)\n\n        # Connect signals\n        self.send_button.clicked.connect(self.send_message)\n        self.input_box.returnPressed.connect(self.send_message)\n\n        # ✅ Only show widget (do not call app.exec_())\n        self.qt_widget.show()\n\n    def send_message(self):\n        text = self.input_box.text().strip()\n        if not text:\n            return\n\n        # Push PDU\n        self.message_port_pub(pmt.intern(\"out\"), pmt.string_to_symbol(text))\n\n        # Create bubble\n        bubble = QtWidgets.QLabel(text)\n        bubble.setWordWrap(True)\n        bubble.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: qlineargradient(x1:0, y1:0, x2:1, y2:1,\n                    stop:0 #4CAF50, stop:1 #66BB6A);\n                color: white;\n                border-radius: 15px;\n                padding: 10px 15px;\n                font-size: 32px;\n            }\n        \"\"\")\n\n        bubble.setSizePolicy(QtWidgets.QSizePolicy.Minimum, QtWidgets.QSizePolicy.Minimum)\n        bubble.adjustSize()\n\n        # Limit max width\n        max_width = 500\n        if bubble.width() > max_width:\n            bubble.setFixedWidth(max_width)\n\n        bubble.setMinimumHeight(bubble.sizeHint().height())\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0, 0, 0, 100))\n        bubble.setGraphicsEffect(effect)\n\n        # Add to chat\n        self.chat_layout.addWidget(bubble, alignment=QtCore.Qt.AlignRight)\n\n        # Auto-scroll\n        QtCore.QTimer.singleShot(100, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n        self.input_box.clear()\n\n"
    bg_image: '''/Users/ravindutennakoon/Downloads/pexels-pixabay-263402.jpg'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          PDU to UTF-8 Text File Writer
          - Overwrites at start of simulation
          - Writes only payloads (clean UTF-8)
          - Appends for subsequent PDUs
          """

          def __init__(self, file_path="output.txt"):
              gr.basic_block.__init__(
                  self,
                  name="PDU to File Writer",
                  in_sig=[],
                  out_sig=[]
              )
              self.file_path = file_path
              self.first_write = True  # ensures overwrite once
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self._write)

          def _write(self, msg):
              if not pmt.is_pair(msg):
                  return
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return

              # Extract bytes
              data = bytearray(pmt.u8vector_elements(vec))
              try:
                  # Safely decode as UTF-8
                  text = data.decode("utf-8", errors="ignore")

                  # Overwrite first time, then append
                  mode = "w" if self.first_write else "a"
                  with open(self.file_path, mode, encoding="utf-8") as f:
                      f.write(text)

                  self.first_write = False
                  print(f"[TextFile] Wrote {len(text)} chars to {self.file_path}")

              except Exception as e:
                  print(f"[TextFile] Error writing: {e}")
    file_path: r"/home/ravindu/Downloads/rx.txt"
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport threading\nimport pmt\nfrom gnuradio import gr\nimport time\n\nclass pdu_text_gui(gr.basic_block):\n    \"\"\"\n    Custom block: QT GUI Message Entry -> PDU sender with Go-Back-N ARQ.\n    - Splits text into packets (2 bytes: [address, seq_id] + payload)\n    - Sends packets in a sliding window\n    - Waits for ACKs [0xAA, seq_id]\n    - On timeout, retransmits all unACKed packets in window\n    - After full message, sends END packet [address, seq_id] (no payload)\n    \"\"\"\n\n    def __init__(self, wait_time=2.0, pkt_size=32, address=0x01, retry_limit=100, window_size=4):\n        gr.basic_block.__init__(\n            self,\n            name=\"GUI Text to PDU with Go-Back-N ARQ\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # Parameters\n        self._timeout = float(wait_time)\n        self._pkt_size = int(pkt_size)\n        self._address = int(address) & 0xFF\n        self._retry_limit = int(retry_limit)\n        self._window_size = int(window_size)\n\n        # Sequence ID\n        self._seq_id = 1  # 0x01..0xFF, avoid 0x00\n\n        # Message ports\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self._process_text)\n\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self._process_ack)\n\n        # Thread + synchronization\n        self._thread = None\n        self._stop_event = threading.Event()\n        self._lock = threading.Lock()\n\n        # Buffers\n        self._text_data = b\"\"\n        self._packets = []\n        self._base = 0          # first unACKed packet index\n        self._next_to_send = 0  # next packet index to send\n        self._attempts = 0\n\n    # ---------------------------\n    # Message handler from GUI\n    # ---------------------------\n    def _process_text(self, msg):\n        try:\n            if pmt.is_symbol(msg):\n                text_str = pmt.symbol_to_string(msg)\n            elif pmt.is_string(msg):\n                text_str = pmt.string_to_string(msg)\n            else:\n                print(\"[pdu_text_gui] Invalid PMT message type\")\n                return\n\n            self._text_data = text_str.encode(\"utf-8\")\n\n            # Start sending in a separate thread\n            if self._thread is None or not self._thread.is_alive():\n                self._stop_event.clear()\n                self._thread = threading.Thread(target=self._run)\n                self._thread.daemon = True\n                self._thread.start()\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] Error processing text: {e}\")\n\n    # ---------------------------\n    # Sending loop (Go-Back-N)\n    # ---------------------------\n    def _run(self):\n        raw = self._text_data\n        step = self._pkt_size - 2\n        blocks = [raw[i:i+step] for i in range(0, len(raw), step)]\n\n        # Build packets with headers\n        self._packets = []\n        for block in blocks:\n            packet = bytes([self._address, self._seq_id]) + block\n            self._packets.append((self._seq_id, packet))\n            self._seq_id = (self._seq_id + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n\n        # Add END packet (address + seq_id, no payload)\n        end_packet = bytes([self._address, self._seq_id])\n        self._packets.append((self._seq_id, end_packet))\n        print(f\"[pdu_text_gui] End packet prepared (id=0x{self._seq_id:02X})\")\n        self._seq_id = (self._seq_id + 1) & 0xFF\n        if self._seq_id == 0:\n            self._seq_id = 1\n\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n\n        while self._base < len(self._packets) and not self._stop_event.is_set():\n            with self._lock:\n                # Send up to window_size packets\n                while self._next_to_send < self._base + self._window_size and self._next_to_send < len(self._packets):\n                    seq_id, packet = self._packets[self._next_to_send]\n                    vec = pmt.init_u8vector(len(packet), list(packet))\n                    pdu = pmt.cons(pmt.PMT_NIL, vec)\n                    self.message_port_pub(pmt.intern(\"out\"), pdu)\n                    if len(packet) > 2:\n                        print(f\"[pdu_text_gui] Packet id=0x{seq_id:02X} sent\")\n                    else:\n                        print(f\"[pdu_text_gui] END packet id=0x{seq_id:02X} sent\")\n                    self._next_to_send += 1\n\n            # Wait for ACK\n            time.sleep(self._timeout)\n\n            with self._lock:\n                if self._base < self._next_to_send:  # still unACKed packets\n                    self._attempts += 1\n                    if self._attempts >= self._retry_limit:\n                        print(\"[pdu_text_gui] Failed: retry limit exceeded\")\n                        self._stop_event.set()\n                        break\n                    print(\"[pdu_text_gui] Timeout: retransmitting window\")\n                    # retransmit all unACKed packets\n                    for i in range(self._base, self._next_to_send):\n                        seq_id, packet = self._packets[i]\n                        vec = pmt.init_u8vector(len(packet), list(packet))\n                        pdu = pmt.cons(pmt.PMT_NIL, vec)\n                        self.message_port_pub(pmt.intern(\"out\"), pdu)\n                        if len(packet) > 2:\n                            print(f\"[pdu_text_gui] Retransmit id=0x{seq_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] Retransmit END id=0x{seq_id:02X}\")\n\n    # ---------------------------\n    # ACK handler\n    # ---------------------------\n    def _process_ack(self, msg):\n        try:\n            payload = pmt.cdr(msg)\n            if not pmt.is_u8vector(payload):\n                return\n\n            arr = bytearray(pmt.u8vector_elements(payload))\n            if len(arr) < 2 or arr[0] != 0xAA:\n                return\n\n            ack_id = arr[1]\n            with self._lock:\n                # slide window if ACK is valid\n                for i in range(self._base, self._next_to_send):\n                    seq_id, _ = self._packets[i]\n                    if seq_id == ack_id:\n                        if len(self._packets[i][1]) > 2:\n                            print(f\"[pdu_text_gui] ACK received for id=0x{ack_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] ACK received for END id=0x{ack_id:02X}\")\n                        self._base = i + 1\n                        self._attempts = 0  # reset retries\n                        break\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] Error processing ACK: {e}\")\n\n"
    address: '15'
    pkt_size: '32'
    retry_limit: '100'
    wait_time: '0.2'
    window_size: '7'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '15'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '50'
  states: {}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\nclass multi_sender_gui(gr.basic_block):\n    \"\"\"\n    Multi-sender PDU GUI with dark bluish-grey left panel\n    and Messenger-style scalable chat bubbles with auto height.\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(self,\n            name=\"Multi-Sender PDU Viewer\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.bg_image = bg_image\n        self.msg_queue = []\n        self.sender_msgs = {}\n        self.sender_buttons = {}\n        self.current_sender = None\n        self.unread = set()\n\n        # PDU input\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n\n        # Ensure QApplication exists\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        # Initialize GUI\n        self.init_gui()\n\n    def init_gui(self):\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Multi-Sender PDU Viewer\")\n        self.qt_widget.resize(800, 500)\n\n        main_layout = QtWidgets.QHBoxLayout()\n        main_layout.setContentsMargins(0,0,0,0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Left: sender panel\n        self.sender_layout_widget = QtWidgets.QWidget()\n        self.sender_layout_widget.setStyleSheet(\"background-color: #1B263B;\")\n        self.sender_layout = QtWidgets.QVBoxLayout()\n        self.sender_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.sender_layout_widget.setLayout(self.sender_layout)\n        main_layout.addWidget(self.sender_layout_widget)\n        self.sender_layout_widget.setFixedWidth(150)\n\n        # Right: chat with wallpaper\n        self.scroll_area = WallpaperScrollArea(bg_image=self.bg_image)\n        self.scroll_area.setWidgetResizable(True)\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Show widget\n        self.qt_widget.show()\n\n        # Timer to process incoming messages\n        self.timer = QtCore.QTimer()\n        self.timer.timeout.connect(self.process_queue)\n        self.timer.start(50)\n\n    def handle_pdu(self, msg):\n        self.msg_queue.append(msg)\n\n    def process_queue(self):\n        while self.msg_queue:\n            msg = self.msg_queue.pop(0)\n            self.store_message(msg)\n\n    def store_message(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 1:\n            return\n\n        sender_bytes = data[0:1]\n        sender = f\"Node {sender_bytes[0]:02X}\"\n        payload = data[1:]\n\n        try:\n            text = payload.decode(\"utf-8\", errors=\"ignore\")\n        except Exception:\n            text = \"<decode error>\"\n\n        if sender not in self.sender_msgs:\n            self.sender_msgs[sender] = []\n            self.add_sender_slot(sender)\n        self.sender_msgs[sender].append(text)\n\n        if self.current_sender != sender:\n            self.unread.add(sender)\n            self.update_sender_slot(sender)\n\n        if self.current_sender == sender or self.current_sender is None:\n            self.display_sender_messages(sender)\n\n    def add_sender_slot(self, sender):\n        slot_widget = QtWidgets.QWidget()\n        slot_widget.setFixedHeight(50)\n        slot_widget.setStyleSheet(\"\"\"\n            background-color: #2C3E50;\n            border-radius: 8px;\n        \"\"\")\n        layout = QtWidgets.QHBoxLayout()\n        layout.setContentsMargins(10,0,10,0)\n        slot_widget.setLayout(layout)\n\n        name_label = QtWidgets.QLabel(sender)\n        name_label.setStyleSheet(\"color: white; font-weight: bold;\")\n        layout.addWidget(name_label, alignment=QtCore.Qt.AlignLeft)\n\n        dot_label = QtWidgets.QLabel(\"\\u25CF\")\n        dot_label.setStyleSheet(\"color: yellow; font-weight: bold;\")\n        dot_label.setVisible(False)\n        layout.addWidget(dot_label, alignment=QtCore.Qt.AlignRight)\n\n        slot_widget.mousePressEvent = lambda e, s=sender: self.display_sender_messages(s)\n\n        self.sender_buttons[sender] = {'widget': slot_widget, 'dot': dot_label, 'name': name_label}\n        self.sender_layout.addWidget(slot_widget)\n\n    def update_sender_slot(self, sender):\n        btn_info = self.sender_buttons.get(sender)\n        if btn_info:\n            btn_info['dot'].setVisible(sender in self.unread)\n\n    def display_sender_messages(self, sender):\n        self.current_sender = sender\n        if sender in self.unread:\n            self.unread.remove(sender)\n            self.update_sender_slot(sender)\n\n        # Clear chat layout\n        for i in reversed(range(self.chat_layout.count())):\n            w = self.chat_layout.takeAt(i).widget()\n            if w:\n                w.deleteLater()\n\n        msgs = self.sender_msgs.get(sender, [])\n        for text in msgs:\n            self.add_bubble(text)\n\n        QtCore.QTimer.singleShot(50, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n    def add_bubble(self, text):\n        bubble = QtWidgets.QLabel(text)\n        bubble.setWordWrap(True)\n        bubble.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #2196F3;\n                color: white;\n                border-radius: 15px;\n                padding: 20px 30px;\n                font-size: 32px;\n            }\n        \"\"\")\n\n        # Auto-height fix for short messages\n        max_width = 500\n        bubble.setMaximumWidth(max_width)\n        bubble.setSizePolicy(QtWidgets.QSizePolicy.Preferred, QtWidgets.QSizePolicy.Minimum)\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0,0,0,100))\n        bubble.setGraphicsEffect(effect)\n\n        # Container for alignment\n        container = QtWidgets.QWidget()\n        layout = QtWidgets.QVBoxLayout()\n        layout.setAlignment(QtCore.Qt.AlignLeft)\n        layout.setContentsMargins(0,0,0,0)\n        layout.addWidget(bubble)\n        container.setLayout(layout)\n\n        self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)\n\n"
    bg_image: '''/Users/ravindutennakoon/Downloads/pexels-pixabay-263402.jpg'''
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport pmt\nimport zlib\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    \"\"\"\n    CRC32 Checker + Dedup + Forwarder\n    - Input : [address | seq_id | payload | crc32]\n    - Output: [payload only] if CRC valid, not duplicate, and address matches self._id\n    - Sends ACKs for valid packets addressed to this ID\n    \"\"\"\n\n    def __init__(self, node_id=0x01):\n        gr.basic_block.__init__(\n            self,\n            name=\"CRC32 Dedup + Forwarder\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self._id = int(node_id) & 0xFF   # this node's address\n        self.received_ids = set()        # track processed (addr, seq_id) pairs\n\n        # Ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))      # forward payload\n        self.message_port_register_out(pmt.intern(\"ack_out\"))  # ACKs\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._handle_msg)\n\n    def _handle_msg(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 6:  # at least [addr | id | CRC32]\n            print(\"[CRC32] Frame too short\")\n            return\n\n        addr = data[0]\n        pkt_id = data[1]\n        payload = data[2:-4]\n        recv_crc = int.from_bytes(data[-4:], \"big\")\n        calc_crc = zlib.crc32(bytes([addr, pkt_id]) + payload) & 0xFFFFFFFF\n\n        if calc_crc != recv_crc:\n            print(f\"[CRC32] FAIL (Addr 0x{addr:02X}, ID {pkt_id})\")\n            return\n\n        # Drop packets not for us\n        if addr != self._id:\n            print(f\"[CRC32] Packet for Addr 0x{addr:02X}, ignored (this node = 0x{self._id:02X})\")\n            return\n\n        # ✅ CRC OK and address match\n        print(f\"[CRC32] OK (Addr 0x{addr:02X}, ID {pkt_id})\")\n\n        # Always ACK valid packets addressed to us\n        ack_bytes = bytes([0xAA, pkt_id])\n        ack_vec = pmt.init_u8vector(len(ack_bytes), list(ack_bytes))\n        ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)\n        self.message_port_pub(pmt.intern(\"ack_out\"), ack_pdu)\n\n        # Dedup check\n        if (addr, pkt_id) not in self.received_ids:\n            self.received_ids.add((addr, pkt_id))\n            try:\n                # Forward payload only\n                text = payload.decode(\"utf-8\", errors=\"ignore\")\n                clean_bytes = text.encode(\"utf-8\")\n                out_vec = pmt.init_u8vector(len(clean_bytes), list(clean_bytes))\n                out_msg = pmt.cons(pmt.PMT_NIL, out_vec)\n                self.message_port_pub(pmt.intern(\"out\"), out_msg)\n                print(f\"[Forward] Addr 0x{addr:02X}, ID {pkt_id} → {len(clean_bytes)} bytes forwarded\")\n            except Exception as e:\n                print(f\"[Forward] UTF-8 decode error: {e}\")\n        else:\n            print(f\"[Forward] Addr 0x{addr:02X}, ID {pkt_id} duplicate, not forwarded\")\n\n"
    node_id: '15'
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport pmt\nimport zlib\nfrom gnuradio import gr\n\nclass crc_forwarder(gr.basic_block):\n    \"\"\"\n    CRC32 Checker + Dedup + Forwarder (Message Reassembler)\n    - Input : [addr | seq_id | payload | crc32]\n    - Output: [addr | full_message] only when end marker received\n    - End marker: valid packet with empty payload\n    \"\"\"\n\n    def __init__(self, my_addr=0x01):\n        gr.basic_block.__init__(\n            self,\n            name=\"CRC32 Dedup + Forwarder\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.my_addr = my_addr & 0xFF\n        self.received_ids = set()       # track processed (addr, seq_id)\n        self.buffers = {}               # per-addr message buffer\n\n        # Ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))      # forward reassembled message\n        self.message_port_register_out(pmt.intern(\"ack_out\"))  # ACKs\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._handle_msg)\n\n    def _handle_msg(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 6:  # minimum frame length [addr | seq | (opt payload) | crc32]\n            print(\"[CRC32] Frame too short\")\n            return\n\n        addr = data[0]\n        pkt_id = data[1]\n        payload = data[2:-4]\n        recv_crc = int.from_bytes(data[-4:], \"big\")\n        calc_crc = zlib.crc32(bytes([addr, pkt_id]) + payload) & 0xFFFFFFFF\n\n        # Filter by address\n        if addr != self.my_addr:\n            print(f\"[CRC32] Ignored (Frame for Addr 0x{addr:02X}, expecting 0x{self.my_addr:02X})\")\n            return\n\n        if calc_crc != recv_crc:\n            print(f\"[CRC32] FAIL (Addr 0x{addr:02X}, ID {pkt_id})\")\n            return\n\n        # ✅ CRC OK\n        print(f\"[CRC32] OK (Addr 0x{addr:02X}, ID {pkt_id})\")\n\n        # Always ACK valid packet\n        ack_bytes = bytes([0xAA, pkt_id])\n        ack_vec = pmt.init_u8vector(len(ack_bytes), list(ack_bytes))\n        ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)\n        self.message_port_pub(pmt.intern(\"ack_out\"), ack_pdu)\n\n        # Deduplication\n        if (addr, pkt_id) in self.received_ids:\n            print(f\"[Forward] Addr 0x{addr:02X}, ID {pkt_id} duplicate, ignored\")\n            return\n        self.received_ids.add((addr, pkt_id))\n\n        # Empty payload = END marker\n        if len(payload) == 0:\n            if addr in self.buffers and self.buffers[addr]:\n                full_payload = b''.join(self.buffers[addr])\n                forward_bytes = bytes([addr]) + full_payload\n                out_vec = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n                out_msg = pmt.cons(pmt.PMT_NIL, out_vec)\n                self.message_port_pub(pmt.intern(\"out\"), out_msg)\n                print(f\"[Forward] Addr 0x{addr:02X}, END marker → {len(full_payload)} bytes reassembled and forwarded\")\n            else:\n                print(f\"[Forward] Addr 0x{addr:02X}, END marker but no buffered data\")\n            # Clear buffer for next message\n            self.buffers[addr] = []\n        else:\n            # Buffer payload for this address\n            if addr not in self.buffers:\n                self.buffers[addr] = []\n            self.buffers[addr].append(payload)\n            print(f\"[Buffer] Addr 0x{addr:02X}, ID {pkt_id} → {len(payload)} bytes buffered (total {sum(len(p) for p in self.buffers[addr])})\")\n\n"
    my_addr: '15'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Cryptodome.Cipher import AES
      from Cryptodome.Util.Padding import pad

      class aes_encrypt(gr.basic_block):
          """
          AES Encryption Block
          - Encrypts PDUs using AES-128-CBC
          - Key & IV fixed for demo (replace with secure exchange in real systems)
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Encrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  enc_data = cipher.encrypt(pad(data, AES.block_size))

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(enc_data), list(enc_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad

      class aes_encrypt(gr.basic_block):
          """
          AES Encryption Block
          - Encrypts PDUs using AES-128-CBC
          - Key & IV fixed for demo (replace with secure exchange in real systems)
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Encrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  enc_data = cipher.encrypt(pad(data, AES.block_size))

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(enc_data), list(enc_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Cryptodome.Cipher import AES
      from Cryptodome.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,1,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: Frequency Spectrum of Tx ACK
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum of ACK
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX-SPECTRUM
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    name: RX-SPECTRUM of ACK
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 2.4e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, epy_block_5, in]
- [digital_crc_append_0, out, epy_block_5_0, in]
- [digital_crc_append_0_0, out, epy_block_0_0, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_0_0, out, digital_protocol_formatter_async_0_0, in]
- [epy_block_0_1, out, epy_block_2_0, in]
- [epy_block_0_1_0, out, epy_block_2_0, in]
- [epy_block_2_0, out, digital_crc_append_0, in]
- [epy_block_3, out, epy_block_6, in]
- [epy_block_3, out, epy_block_6_0, in]
- [epy_block_3_0, out, epy_block_2_0, ack_in]
- [epy_block_4, ack_out, digital_crc_append_0_0, in]
- [epy_block_4, out, epy_block_1, in]
- [epy_block_4_0, ack_out, digital_crc_append_0_0, in]
- [epy_block_4_0, out, epy_block_1, in]
- [epy_block_4_0, out, epy_block_3_1, in]
- [epy_block_5, out, epy_block_0, in]
- [epy_block_5_0, out, epy_block_0, in]
- [epy_block_6, out, epy_block_4, in]
- [epy_block_6, out, epy_block_4_0, in]
- [epy_block_6_0, out, epy_block_4_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
