options:
  parameters:
    author: BellLabz
    category: Custom
    description: cdp project
    generate_options: qt_gui
    id: cdp
    output_language: python
    title: cdp
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '11100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: ''
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '11100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '32'
    sps: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '20'
  states: {}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\nfrom datetime import datetime  # For timestamps\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\nclass multi_sender_gui(gr.basic_block):\n    \"\"\"\n    Multi-sender PDU GUI with dark bluish-grey left panel\n    and Messenger-style scalable chat bubbles with timestamps.\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(self,\n            name=\"Multi-Sender PDU Viewer\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.bg_image = bg_image\n        self.msg_queue = []\n        self.sender_msgs = {}\n        self.sender_buttons = {}\n        self.current_sender = None\n        self.unread = set()\n\n        # PDU input\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n\n        # Ensure QApplication exists\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        # Initialize GUI\n        self.init_gui()\n\n    def init_gui(self):\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Multi-Sender PDU Viewer\")\n        self.qt_widget.resize(800, 500)\n\n        main_layout = QtWidgets.QHBoxLayout()\n        main_layout.setContentsMargins(0,0,0,0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Left: sender panel\n        self.sender_layout_widget = QtWidgets.QWidget()\n        self.sender_layout_widget.setStyleSheet(\"background-color: #1B263B;\")\n        self.sender_layout = QtWidgets.QVBoxLayout()\n        self.sender_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.sender_layout_widget.setLayout(self.sender_layout)\n        main_layout.addWidget(self.sender_layout_widget)\n        self.sender_layout_widget.setFixedWidth(150)\n\n        # Right: chat with wallpaper\n        self.scroll_area = WallpaperScrollArea(bg_image=self.bg_image)\n        self.scroll_area.setWidgetResizable(True)\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Show widget\n        self.qt_widget.show()\n\n        # Timer to process incoming messages\n        self.timer = QtCore.QTimer()\n        self.timer.timeout.connect(self.process_queue)\n        self.timer.start(50)\n\n    def handle_pdu(self, msg):\n        self.msg_queue.append(msg)\n\n    def process_queue(self):\n        while self.msg_queue:\n            msg = self.msg_queue.pop(0)\n            self.store_message(msg)\n\n    def store_message(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 1:\n            return\n\n        sender_bytes = data[0:1]\n        sender = f\"Node {sender_bytes[0]:02X}\"\n        payload = data[1:]\n\n        try:\n            text = payload.decode(\"utf-8\", errors=\"ignore\")\n        except Exception:\n            text = \"<decode error>\"\n\n        if sender not in self.sender_msgs:\n            self.sender_msgs[sender] = []\n            self.add_sender_slot(sender)\n        self.sender_msgs[sender].append(text)\n\n        if self.current_sender != sender:\n            self.unread.add(sender)\n            self.update_sender_slot(sender)\n\n        if self.current_sender == sender or self.current_sender is None:\n            self.display_sender_messages(sender)\n\n    def add_sender_slot(self, sender):\n        slot_widget = QtWidgets.QWidget()\n        slot_widget.setFixedHeight(50)\n        slot_widget.setStyleSheet(\"\"\"\n            background-color: #2C3E50;\n            border-radius: 8px;\n        \"\"\")\n        layout = QtWidgets.QHBoxLayout()\n        layout.setContentsMargins(10,0,10,0)\n        slot_widget.setLayout(layout)\n\n        name_label = QtWidgets.QLabel(sender)\n        name_label.setStyleSheet(\"color: white; font-weight: bold;\")\n        layout.addWidget(name_label, alignment=QtCore.Qt.AlignLeft)\n\n        dot_label = QtWidgets.QLabel(\"\\u25CF\")\n        dot_label.setStyleSheet(\"color: yellow; font-weight: bold;\")\n        dot_label.setVisible(False)\n        layout.addWidget(dot_label, alignment=QtCore.Qt.AlignRight)\n\n        slot_widget.mousePressEvent = lambda e, s=sender: self.display_sender_messages(s)\n\n        self.sender_buttons[sender] = {'widget': slot_widget, 'dot': dot_label, 'name': name_label}\n        self.sender_layout.addWidget(slot_widget)\n\n    def update_sender_slot(self, sender):\n        btn_info = self.sender_buttons.get(sender)\n        if btn_info:\n            btn_info['dot'].setVisible(sender in self.unread)\n\n    def display_sender_messages(self, sender):\n        self.current_sender = sender\n        if sender in self.unread:\n            self.unread.remove(sender)\n            self.update_sender_slot(sender)\n\n        # Clear chat layout\n        for i in reversed(range(self.chat_layout.count())):\n            w = self.chat_layout.takeAt(i).widget()\n            if w:\n                w.deleteLater()\n\n        msgs = self.sender_msgs.get(sender, [])\n        for text in msgs:\n            self.add_bubble(text)\n\n        QtCore.QTimer.singleShot(50, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n    def add_bubble(self, text):\n        # Chat bubble\n        bubble = QtWidgets.QLabel(text)\n        bubble.setWordWrap(True)\n        bubble.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #2196F3;\n                color: white;\n                border-radius: 15px;\n                padding: 20px 30px;\n                font-size: 32px;\n            }\n        \"\"\")\n        bubble.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Minimum)\n        bubble.setMaximumWidth(500)\n        bubble.setMinimumHeight(bubble.sizeHint().height())\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0,0,0,100))\n        bubble.setGraphicsEffect(effect)\n\n        # Timestamp with small green \"pill\"\n        timestamp = QtWidgets.QLabel(datetime.now().strftime(\"%H:%M\"))\n        timestamp.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #4CAF50;  /* green background */\n                color: white;\n                font-size: 18px;\n                border-radius: 8px;\n                padding: 2px 6px;\n            }\n        \"\"\")\n        timestamp.setAlignment(QtCore.Qt.AlignRight)\n        timestamp.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)  # <-- small pill only\n\n        # Container for bubble + timestamp\n        container = QtWidgets.QWidget()\n        layout = QtWidgets.QVBoxLayout()\n        layout.setAlignment(QtCore.Qt.AlignLeft)\n        layout.setContentsMargins(0,0,0,0)\n        layout.addWidget(bubble)\n        layout.addWidget(timestamp, alignment=QtCore.Qt.AlignRight)  # timestamp right-aligned\n        container.setLayout(layout)\n\n        self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)\n\n# Run GUI for standalone testing\nif __name__ == \"__main__\":\n    app = QtWidgets.QApplication(sys.argv)\n    gui = multi_sender_gui()\n    sys.exit(app.app.exec_())\n\n"
    bg_image: '''/home/vboxuser/Downloads/Networks_Telecommunications.jpg'''
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport pmt\nimport zlib\nfrom gnuradio import gr\n\nclass crc_forwarder(gr.basic_block):\n    \"\"\"\n    CRC32 Checker + Dedup + Forwarder (Message Reassembler)\n    - Input : [sender_addr | seq_id | payload | crc32]\n    - Output: [sender_addr | full_message] only when end marker received\n    - End marker: valid packet with empty payload\n    - Handles multiple senders dynamically\n    - ACK prepends transmitter's address and appends CRC32\n    \"\"\"\n\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name=\"CRC32 Dedup + Forwarder\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.received_ids = set()  # track processed (addr, seq_id)\n        self.buffers = {}          # per-sender message buffer\n\n        # Ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))      # forward reassembled message\n        self.message_port_register_out(pmt.intern(\"ack_out\"))  # ACKs\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._handle_msg)\n\n        print(\"[CRC32] Receiver initialized\")\n\n    def _handle_msg(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 6:  # minimum frame length [addr | seq | (opt payload) | crc32]\n            print(\"[CRC32] Frame too short\")\n            return\n\n        sender_addr = data[0]  # transmitter address\n        pkt_id = data[1]\n        payload = data[2:-4]\n        recv_crc = int.from_bytes(data[-4:], \"big\")\n        calc_crc = zlib.crc32(bytes([sender_addr, pkt_id]) + payload) & 0xFFFFFFFF\n\n        if calc_crc != recv_crc:\n            print(f\"[CRC32] FAIL (Addr 0x{sender_addr:02X}, ID {pkt_id})\")\n            return\n\n        # ✅ CRC OK\n        print(f\"[CRC32] OK (Addr 0x{sender_addr:02X}, ID {pkt_id})\")\n\n        # --- Construct ACK like address_add block, then append CRC32 ---\n        ack_data = bytearray([sender_addr, 0xAA, pkt_id])\n        ack_crc = zlib.crc32(ack_data) & 0xFFFFFFFF\n        ack_data += ack_crc.to_bytes(4, 'big')\n\n        ack_vec = pmt.init_u8vector(len(ack_data), list(ack_data))\n        ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)\n        self.message_port_pub(pmt.intern(\"ack_out\"), ack_pdu)\n        print(f\"[ACK] Sent to transmitter Addr 0x{sender_addr:02X}, ID {pkt_id}, CRC32 0x{ack_crc:08X}\")\n\n        # Deduplication\n        if (sender_addr, pkt_id) in self.received_ids:\n            print(f\"[Forward] Addr 0x{sender_addr:02X}, ID {pkt_id} duplicate, ignored\")\n            return\n        self.received_ids.add((sender_addr, pkt_id))\n\n        # Empty payload = END marker\n        if len(payload) == 0:\n            if sender_addr in self.buffers and self.buffers[sender_addr]:\n                full_payload = b''.join(self.buffers[sender_addr])\n                forward_bytes = bytes([sender_addr]) + full_payload\n                out_vec = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n                out_msg = pmt.cons(pmt.PMT_NIL, out_vec)\n                self.message_port_pub(pmt.intern(\"out\"), out_msg)\n                print(f\"[Forward] Addr 0x{sender_addr:02X}, END marker → {len(full_payload)} bytes reassembled and forwarded\")\n            else:\n                print(f\"[Forward] Addr 0x{sender_addr:02X}, END marker but no buffered data\")\n            self.buffers[sender_addr] = []\n        else:\n            if sender_addr not in self.buffers:\n                self.buffers[sender_addr] = []\n            self.buffers[sender_addr].append(payload)\n            total_len = sum(len(p) for p in self.buffers[sender_addr])\n            print(f\"[Buffer] Addr 0x{sender_addr:02X}, ID {pkt_id} → {len(payload)} bytes buffered (total {total_len})\")\n\n"
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Cryptodome.Cipher import AES
      from Cryptodome.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: Frequency Spectrum of Tx ACK
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum of ACK
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX-SPECTRUM
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 5.8e9
    gain: '50'
    samp_rate: samp_rate_blade*4
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 2.4e9
    gain: '50'
    samp_rate: samp_rate*4
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: out
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [epy_block_3, out, epy_block_4_0, in]
- [epy_block_3, out, epy_block_6, in]
- [epy_block_4_0, ack_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_4_0, out, epy_block_3_1, in]
- [epy_block_6, out, epy_block_4_0, in]
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_1, '0', pdu_tagged_stream_to_pdu_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
