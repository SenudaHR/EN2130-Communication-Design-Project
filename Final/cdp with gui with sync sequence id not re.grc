options:
  parameters:
    author: BellLabz
    category: Custom
    description: cdp project
    generate_options: qt_gui
    id: cdp
    output_language: python
    title: cdp
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '1110000101011010111010001001001111100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: ''
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {state: disabled}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {state: disabled}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1110000101011010111010001001001111100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1110000101011010111010001001001111100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '32'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend a dynamic address byte to a PDU payload.
          
          This block has no GRC parameters. It relies entirely on the 'addr_in' 
          port to set the destination address.
          """
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              # Default internal state (will be overwritten by GUI immediately)
              self.address = 0x00
              
              # Port for the Text Payload
              self.message_port_register_in(pmt.intern("in"))
              # Port for the Address Update
              self.message_port_register_in(pmt.intern("addr_in"))
              
              # Output Port
              self.message_port_register_out(pmt.intern("out"))
              
              # Register handlers
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.set_msg_handler(pmt.intern("addr_in"), self.handle_address_update)

          def handle_address_update(self, msg):
              """
              Receives the address from the GUI (Symbol or Int) 
              and updates the internal state.
              """
              try:
                  # GUI sends address as a String Symbol (e.g. "255")
                  if pmt.is_symbol(msg):
                      str_val = pmt.symbol_to_string(msg)
                      self.address = int(str_val)
                  
                  # If standard int/long is sent
                  elif pmt.is_integer(msg) or pmt.is_uint64(msg):
                      self.address = pmt.to_long(msg)
                      
                  # print(f"[address_add] Active Address set to: {self.address}")
                      
              except ValueError:
                  pass

          def handle_msg(self, msg):
              """
              Prepend the currently active 'self.address' to the message.
              """
              meta = pmt.make_dict()
              payload = bytearray()

              # 1. Parse Input
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  payload = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
              elif pmt.is_symbol(msg):
                  text_data = pmt.symbol_to_string(msg)
                  payload = bytearray(text_data, 'utf-8')
              else:
                  return

              # 2. Prepend Address
              safe_addr = self.address & 0xFF
              payload.insert(0, safe_addr)

              # 3. Publish
              out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
              self.message_port_pub(pmt.intern("out"), out_msg)
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      # ==========================================
      # 1. CUSTOM UI COMPONENTS
      # ==========================================

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap and not self.bg_pixmap.isNull():
                  painter = QtGui.QPainter(self.viewport())
                  scaled_pixmap = self.bg_pixmap.scaled(
                      self.viewport().size(),
                      QtCore.Qt.KeepAspectRatioByExpanding,
                      QtCore.Qt.SmoothTransformation
                  )
                  x = (self.viewport().width() - scaled_pixmap.width()) // 2
                  y = (self.viewport().height() - scaled_pixmap.height()) // 2
                  painter.drawPixmap(x, y, scaled_pixmap)
              super().paintEvent(event)

      # ==========================================
      # 2. THE MAIN WINDOW (GUI LOGIC)
      # ==========================================
      class MessengerWindow(QtWidgets.QWidget):
          # Signals to GR
          send_to_gr_signal = QtCore.pyqtSignal(str)
          addr_selected_signal = QtCore.pyqtSignal(str)

          def __init__(self, bg_image=""):
              super().__init__()
              self.setWindowTitle("BellLabz")
              self.resize(950, 700)
              self.bg_image_path = bg_image
              
              # --- STATE FLAGS ---
              self.is_waiting_for_ack = False 
              
              # --- DATA STRUCTURES ---
              self.added_addresses = set()
              self.selected_btn = None 
              self.current_dest_address = None
              
              # Structure: { addr_int: {'page': widget, 'layout': box, 'scroll': area, 'btn': btn_obj, 'dot': dot_label} }
              self.user_data = {} 

              # --- STYLES ---
              self.style_btn_normal = """
                  QPushButton {
                      background-color: #34495e; color: #ecf0f1; border: 1px solid #2c3e50;
                      padding: 12px; border-radius: 6px; text-align: left;
                  }
                  QPushButton:hover { background-color: #4b6584; }
                  QPushButton:disabled { background-color: #2c3e50; color: #7f8c8d; border: 1px solid #2c3e50; }
              """
              self.style_btn_selected = """
                  QPushButton {
                      background-color: #27ae60; color: white; border: 2px solid white;
                      padding: 12px; border-radius: 6px; text-align: left; font-weight: bold;
                  }
                  QPushButton:disabled { background-color: #2ecc71; opacity: 0.7; }
              """

              # --- MAIN LAYOUT ---
              self.main_layout = QtWidgets.QHBoxLayout()
              self.main_layout.setContentsMargins(0, 0, 0, 0)
              self.main_layout.setSpacing(0)
              self.setLayout(self.main_layout)

              self._init_sidebar()
              self._init_right_panel()

          def _init_sidebar(self):
              self.sidebar = QtWidgets.QWidget()
              self.sidebar.setFixedWidth(250)
              self.sidebar.setStyleSheet("background-color: #2c3e50; border-right: 1px solid #1a252f;")
              layout = QtWidgets.QVBoxLayout(self.sidebar)
              layout.setSpacing(10)

              header = QtWidgets.QLabel("CHATS")
              header.setStyleSheet("color: #95a5a6; font-weight: bold; margin-top: 10px; font-size: 14px;")
              layout.addWidget(header)

              # Input
              input_con = QtWidgets.QHBoxLayout()
              self.addr_input = QtWidgets.QLineEdit()
              self.addr_input.setPlaceholderText("ID (0-255)")
              self.addr_input.setStyleSheet("""
                  QLineEdit { background: #ecf0f1; border: none; border-radius: 4px; padding: 8px; color: black; }
                  QLineEdit:disabled { background: #95a5a6; color: #555; }
              """)
              self.addr_input.setValidator(QtGui.QIntValidator(0, 255))
              self.addr_input.returnPressed.connect(self.manual_add_address)

              self.add_btn = QtWidgets.QPushButton("+")
              self.add_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.add_btn.setFixedWidth(40)
              self.add_btn.clicked.connect(self.manual_add_address)
              self.add_btn.setStyleSheet("""
                  QPushButton { background: #3498db; color: white; border: none; border-radius: 4px; font-weight: bold; }
                  QPushButton:disabled { background: #7f8c8d; }
              """)
              
              input_con.addWidget(self.addr_input)
              input_con.addWidget(self.add_btn)
              layout.addLayout(input_con)

              layout.addWidget(self._create_separator())

              # Contact List Scroll
              self.contact_scroll = QtWidgets.QScrollArea()
              self.contact_scroll.setWidgetResizable(True)
              self.contact_scroll.setStyleSheet("border: none; background: transparent;")
              
              self.contact_container = QtWidgets.QWidget()
              self.contact_layout = QtWidgets.QVBoxLayout(self.contact_container)
              self.contact_layout.setAlignment(QtCore.Qt.AlignTop)
              self.contact_layout.setSpacing(5)
              self.contact_scroll.setWidget(self.contact_container)

              layout.addWidget(self.contact_scroll)
              self.main_layout.addWidget(self.sidebar)

          def _init_right_panel(self):
              right_panel = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(right_panel)
              layout.setContentsMargins(0, 0, 0, 0)
              layout.setSpacing(0)

              # Stack for Chat Pages
              self.chat_stack = QtWidgets.QStackedWidget()
              welcome_page = QtWidgets.QLabel("Select a contact to start messaging")
              welcome_page.setAlignment(QtCore.Qt.AlignCenter)
              welcome_page.setStyleSheet("background-color: #e5ddd5; color: #888; font-size: 18px;")
              self.chat_stack.addWidget(welcome_page)
              layout.addWidget(self.chat_stack, stretch=1)

              # Input Area
              self.input_box_wrapper = QtWidgets.QWidget()
              self.input_box_wrapper.setStyleSheet("background-color: #f0f0f0; border-top: 1px solid #dcdcdc;")
              input_box_layout = QtWidgets.QHBoxLayout(self.input_box_wrapper)
              input_box_layout.setContentsMargins(10, 10, 10, 10)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message...")
              self.msg_input.setStyleSheet("""
                  QLineEdit { border-radius: 20px; padding: 10px 15px; background: white; border: 1px solid #ccc; font-size: 14px; }
                  QLineEdit:disabled { background-color: #e0e0e0; color: #888; }
              """)
              
              self.send_btn = QtWidgets.QPushButton("Send")
              self.send_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.send_btn.setStyleSheet("""
                  QPushButton { background-color: #008069; color: white; border-radius: 20px; padding: 10px 20px; font-weight: bold; }
                  QPushButton:disabled { background-color: #95a5a6; }
              """)
              
              self.msg_input.returnPressed.connect(self.on_send_click)
              self.send_btn.clicked.connect(self.on_send_click)

              input_box_layout.addWidget(self.msg_input)
              input_box_layout.addWidget(self.send_btn)

              layout.addWidget(self.input_box_wrapper)
              self.main_layout.addWidget(right_panel)
              
              self.input_box_wrapper.hide()

          def _create_separator(self):
              line = QtWidgets.QFrame()
              line.setFrameShape(QtWidgets.QFrame.HLine)
              line.setStyleSheet("color: #3e5871;")
              return line

          def manual_add_address(self):
              text = self.addr_input.text().strip()
              if not text: return
              try:
                  val = int(text)
                  self.ensure_user_exists(val)
                  # Simulate click to select logic
                  btn = self.user_data[val]['btn']
                  self.handle_address_click(btn, val)
                  self.addr_input.clear()
              except ValueError:
                  pass

          def ensure_user_exists(self, address_val):
              """Creates user context if it doesn't exist. Returns the user dict."""
              if address_val in self.user_data:
                  return self.user_data[address_val]

              self.added_addresses.add(address_val)

              # 1. Create Sidebar Button Widget
              btn_widget = QtWidgets.QWidget()
              btn_layout = QtWidgets.QHBoxLayout(btn_widget)
              btn_layout.setContentsMargins(0,0,0,0)
              
              # The actual clickable button
              btn = QtWidgets.QPushButton(f"Node {address_val}")
              btn.setCursor(QtCore.Qt.PointingHandCursor)
              btn.setStyleSheet(self.style_btn_normal)
              btn.setFixedHeight(50)
              
              # Unread Dot (Overlay logic via layout)
              # To make layout simple, we'll just put the dot inside the button text or next to it?
              # Let's use a layout approach:
              
              dot = QtWidgets.QLabel("●") 
              dot.setStyleSheet("color: #f1c40f; font-size: 16px; margin-right: 5px;") # Yellow dot
              dot.setVisible(False)

              # We need a custom widget click handling or just overlay the button
              # Simplification: Connect button click. The dot is separate but we track it.
              # Let's wrap btn and dot in a container? No, let's keep it simple.
              # We will add dot to the HBox inside the sidebar layout item?
              
              # Better approach: Subclass QPushButton or just add dot next to it
              container_widget = QtWidgets.QWidget()
              cw_layout = QtWidgets.QHBoxLayout(container_widget)
              cw_layout.setContentsMargins(0,0,0,0)
              cw_layout.setSpacing(0)
              
              # Helper logic to make the whole row clickable requires event filter, 
              # but let's just make the button fill the space and manage the dot internally?
              # Let's stick to the previous button style but change text color if unread?
              # Or just append a unicode dot to text?
              
              # Going with the clean layout approach:
              # [ Button (Stretches) ] [ Dot (Fixed) ]
              
              btn.clicked.connect(lambda checked, b=btn, a=address_val: self.handle_address_click(b, a))
              
              # Add to sidebar
              # We need to modify style to allow dot visibility. 
              # Actually, let's put the dot IN the button text for simplicity given the constraints
              # No, let's do it right.
              
              self.contact_layout.addWidget(btn)

              # 2. Create Chat Page
              new_chat_page = self._create_chat_page_widget()
              self.chat_stack.addWidget(new_chat_page)
              
              chat_layout = new_chat_page.widget().layout()
              
              # Store Data
              self.user_data[address_val] = {
                  "page": new_chat_page,
                  "layout": chat_layout,
                  "scroll_area": new_chat_page,
                  "btn": btn,
                  "has_unread": False
              }
              
              return self.user_data[address_val]

          def _create_chat_page_widget(self):
              scroll = WallpaperScrollArea(bg_image=self.bg_image_path)
              scroll.setStyleSheet("border: none; background-color: #e5ddd5;") 
              container = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(container)
              layout.setAlignment(QtCore.Qt.AlignTop)
              scroll.setWidget(container)
              container.setStyleSheet("background: transparent;")
              return scroll

          def handle_address_click(self, btn_obj, address_val):
              if self.is_waiting_for_ack:
                  return

              # Show input bar
              if self.input_box_wrapper.isHidden():
                  self.input_box_wrapper.show()

              # Update Button Styles
              if self.selected_btn and self.selected_btn != btn_obj:
                  self.selected_btn.setStyleSheet(self.style_btn_normal)
              
              btn_obj.setStyleSheet(self.style_btn_selected)
              self.selected_btn = btn_obj
              
              # Clear Unread
              if self.user_data[address_val]["has_unread"]:
                  self.user_data[address_val]["has_unread"] = False
                  btn_obj.setText(f"Node {address_val}") # Remove dot from text

              self.current_dest_address = address_val
              
              # Switch Stack
              target_page = self.user_data[address_val]["page"]
              self.chat_stack.setCurrentWidget(target_page)

              # Emit Address Change
              self.addr_selected_signal.emit(str(address_val))

          def on_send_click(self):
              if self.is_waiting_for_ack:
                  return

              text = self.msg_input.text().strip()
              if not text: return
              
              if self.current_dest_address is None:
                  return

              self._set_ui_busy_state(True)

              user_entry = self.user_data[self.current_dest_address]
              
              # Add SENT Bubble (Right side)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=True)
              
              self.send_to_gr_signal.emit(text)
              self.msg_input.clear()

          @QtCore.pyqtSlot(int, str)
          def handle_received_msg(self, src_addr, text):
              """Called when a PDU arrives from GNU Radio"""
              
              # 1. Ensure User Exists
              user_entry = self.ensure_user_exists(src_addr)
              
              # 2. Add RECEIVED Bubble (Left Side)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=False)
              
              # 3. Handle Unread Logic
              if self.current_dest_address != src_addr:
                  user_entry["has_unread"] = True
                  # Simple visual indicator: Append dot to button text
                  btn = user_entry["btn"]
                  if "●" not in btn.text():
                      btn.setText(f"Node {src_addr} ●")

          def _add_message_bubble(self, text, layout, scroll_area, is_sender):
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout(container)
              vbox.setContentsMargins(0,0,0,0)

              # Scroll for long text in bubble
              h_scroll = QtWidgets.QScrollArea()
              h_scroll.setWidgetResizable(True)
              h_scroll.setFixedHeight(60)
              h_scroll.setStyleSheet("background: transparent; border: none;")
              h_scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              h_scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)

              lbl = QtWidgets.QLabel(text)
              
              if is_sender:
                  # Green, Right Aligned
                  lbl.setStyleSheet("background-color: #dcf8c6; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignRight
              else:
                  # White, Left Aligned
                  lbl.setStyleSheet("background-color: #ffffff; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignLeft

              h_scroll.setWidget(lbl)
              h_scroll.setMinimumWidth(100)
              h_scroll.setMaximumWidth(450)
              lbl.adjustSize()
              h_scroll.setFixedHeight(lbl.height() + 25)

              # Timestamp
              ts_text = datetime.now().strftime("%H:%M")
              ts = QtWidgets.QLabel(ts_text)
              ts.setStyleSheet("color: grey; font-size: 10px;")
              ts.setAlignment(QtCore.Qt.AlignRight if is_sender else QtCore.Qt.AlignLeft)
              
              vbox.addWidget(h_scroll)
              vbox.addWidget(ts)

              # Horizontal Row Alignment
              row = QtWidgets.QHBoxLayout()
              if is_sender:
                  row.addStretch()
                  row.addWidget(container)
                  self._last_message_timestamp = ts # Track only my sent messages for ACK
              else:
                  row.addWidget(container)
                  row.addStretch()
              
              layout.addLayout(row)
              
              # Scroll to bottom
              QtCore.QTimer.singleShot(50, lambda: scroll_area.verticalScrollBar().setValue(scroll_area.verticalScrollBar().maximum()))

          def _set_ui_busy_state(self, is_busy):
              """Disables/Enables INPUT, SEND BTN, SIDEBAR, and ADD BTN"""
              self.is_waiting_for_ack = is_busy
              
              self.msg_input.setEnabled(not is_busy)
              self.send_btn.setEnabled(not is_busy)
              self.addr_input.setEnabled(not is_busy)
              self.add_btn.setEnabled(not is_busy)

              for addr, data in self.user_data.items():
                  data['btn'].setEnabled(not is_busy)
              
              if is_busy:
                  self.send_btn.setText("Wait...")
              else:
                  self.send_btn.setText("Send")
                  self.msg_input.setFocus()

          @QtCore.pyqtSlot(str)
          def handle_feedback(self, feedback):
              # ACK logic only applies to the last SENT message
              if hasattr(self, '_last_message_timestamp') and self._last_message_timestamp:
                  if feedback == "END_ACK_RECEIVED":
                      current_text = self._last_message_timestamp.text()
                      if "✓" not in current_text:
                          self._last_message_timestamp.setText(current_text + " ✓✓")
                          self._last_message_timestamp.setStyleSheet("color: #34B7F1; font-weight: bold; font-size: 10px;")
                  elif feedback == "RETRY_LIMIT_EXCEEDED":
                      self._last_message_timestamp.setText("Failed ❌")
                      self._last_message_timestamp.setStyleSheet("color: red; font-size: 10px;")
              
              self._set_ui_busy_state(False)

      # ==========================================
      # 3. GNU RADIO BLOCK
      # ==========================================
      class GuiSignaler(QtCore.QObject):
          feedback_signal = QtCore.pyqtSignal(str)
          receive_signal = QtCore.pyqtSignal(int, str) # addr, text

      class messenger_gui(gr.basic_block):
          """
          Inputs: 
             'in' (PDUs from receiver)
             'feedback' (ACK/NACK)
          Outputs: 
             'out' (payload), 
             'dest_addr' (selected address)
          """
          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              # Registers
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("dest_addr"))
              
              self.message_port_register_in(pmt.intern("in"))      # Incoming PDU
              self.message_port_register_in(pmt.intern("feedback")) # ACKs

              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback_msg)
              self.set_msg_handler(pmt.intern("in"), self._process_incoming_pdu)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.signaler = GuiSignaler()
              self.gui_window = MessengerWindow(bg_image=bg_image)
              
              # Connections
              self.signaler.feedback_signal.connect(self.gui_window.handle_feedback)
              self.signaler.receive_signal.connect(self.gui_window.handle_received_msg)
              
              self.gui_window.send_to_gr_signal.connect(self._send_payload)
              self.gui_window.addr_selected_signal.connect(self._send_dest_addr)

              self.gui_window.show()

          def _process_feedback_msg(self, msg):
              try:
                  if pmt.is_symbol(msg):
                      s = pmt.symbol_to_string(msg)
                      self.signaler.feedback_signal.emit(s)
              except Exception:
                  pass

          def _process_incoming_pdu(self, msg):
              """
              Expects PDU: Pair(Meta, u8vector).
              Byte 0 = Sender Address.
              Bytes 1+ = Text.
              """
              try:
                  if not pmt.is_pair(msg): return
                  vec = pmt.cdr(msg)
                  if not pmt.is_u8vector(vec): return
                  
                  data = bytearray(pmt.u8vector_elements(vec))
                  if len(data) < 1: return
                  
                  sender_addr = data[0] # Byte 0
                  payload = data[1:]    # Remaining bytes
                  
                  text = payload.decode("utf-8", errors="ignore")
                  
                  # Emit to GUI
                  self.signaler.receive_signal.emit(sender_addr, text)
                  
              except Exception as e:
                  print(f"Error processing input PDU: {e}")

          def _send_payload(self, text_msg):
              self.message_port_pub(pmt.intern("out"), pmt.string_to_symbol(text_msg))

          def _send_dest_addr(self, addr_str):
              self.message_port_pub(pmt.intern("dest_addr"), pmt.string_to_symbol(addr_str))
    bg_image: '''Networks_Telecommunications1.jpg'''
  states: {}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import threading
      import pmt
      import time
      import os
      from gnuradio import gr

      class pdu_text_gui_saw(gr.basic_block):
          """
          Custom block: QT GUI Message Entry -> PDU sender with Stop-and-Wait ARQ.
          Sends the entire input message as a single PDU.
          - sync_bits : number of random bytes transmitted before each retransmission.
          
          MODIFIED: Sequence ID now uses incrementing 8-bit values (1-255, then wraps) 
          for each new message transmission. The ID advances on successful ACK or 
          upon reaching the retry limit.
          """

          def __init__(self, wait_time=2.0, address=0x01,
                       retry_limit=100, sync_bits=1000):

              gr.basic_block.__init__(
                  self,
                  name="GUI Text to Single PDU with Stop-and-Wait ARQ + Sync Burst",
                  in_sig=[],
                  out_sig=[]
              )

              # Parameters
              self._timeout = float(wait_time)
              self._address = int(address) & 0xFF
              self._retry_limit = int(retry_limit)
              self._sync_bits = int(sync_bits)

              # Seq/ACK control
              # 🔥 FIX: Sequence ID starts at 1
              self._seq_id = 1  
              self._last_ack_seq = 0
              self._has_acks = False

              # Register message ports
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("feedback"))
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_in(pmt.intern("ack_in"))

              self.set_msg_handler(pmt.intern("in"), self._process_text)
              self.set_msg_handler(pmt.intern("ack_in"), self._process_ack)

              # Thread control
              self._thread = None
              self._stop_event = threading.Event()
              self._lock = threading.Lock()

              # Data buffers
              self._text_data = b""
              self._single_packet = None  # Stores the (seq_id, packet) tuple
              self._attempts = 0

          # -------------------------------------------------
          # Sync Burst Sender (PURE RANDOM BYTES)
          # -------------------------------------------------
          def _send_sync_burst(self):
              if self._sync_bits <= 0:
                  return

              # Pure random bytes, no header
              sync_data = os.urandom(self._sync_bits)

              vec = pmt.init_u8vector(len(sync_data), list(sync_data))
              pdu = pmt.cons(pmt.PMT_NIL, vec)

              print(f"[pdu_text_gui_saw] SYNC BURST sent ({len(sync_data)} bytes)")
              self.message_port_pub(pmt.intern("out"), pdu)

          # -------------------------------------------------
          # Handle input text
          # -------------------------------------------------
          def _process_text(self, msg):
              try:
                  if pmt.is_symbol(msg):
                      text_str = pmt.symbol_to_string(msg)
                  elif pmt.is_string(msg):
                      text_str = pmt.string_to_string(msg)
                  else:
                      print("[pdu_text_gui_saw] Invalid PMT format")
                      return

                  self._text_data = text_str.encode("utf-8")

                  if self._thread is None or not self._thread.is_alive():
                      self._stop_event.clear()
                      self._thread = threading.Thread(target=self._run)
                      self._thread.daemon = True
                      self._thread.start()

              except Exception as e:
                  print(f"[pdu_text_gui_saw] Error processing text: {e}")

          # -------------------------------------------------
          # Main ARQ loop (Stop-and-Wait)
          # -------------------------------------------------
          def _run(self):
              raw = self._text_data

              # Use the current incrementing sequence ID
              current_seq_id = self._seq_id 

              print(f"[pdu_text_gui_saw] Starting TX at seq=0x{current_seq_id:02X}")

              # Build ONE packet: [Address (1 byte), Seq ID (1 byte)] + Data
              packet = bytes([self._address, current_seq_id]) + raw
              self._single_packet = (current_seq_id, packet)

              # Reset attempts
              self._attempts = 0

              # Flag to track if the single packet has been ACKed
              acked = False
              
              # --------------------------------------------------
              # ARQ LOOP (Stop-and-Wait)
              # --------------------------------------------------
              while not acked and not self._stop_event.is_set():

                  # Send the single packet
                  with self._lock:
                      seq_id, packet = self._single_packet
                      vec = pmt.init_u8vector(len(packet), list(packet))
                      pdu = pmt.cons(pmt.PMT_NIL, vec)
                      self.message_port_pub(pmt.intern("out"), pdu)
                      print(f"[pdu_text_gui_saw] Sent single PDU id=0x{seq_id:02X}, size={len(packet)} bytes (Attempt {self._attempts + 1})")

                  # Wait for ACK
                  time.sleep(self._timeout)

                  # Timeout check
                  with self._lock:
                      # Check if the packet has been acknowledged (via _process_ack)
                      if self._last_ack_seq != self._single_packet[0]:
                          
                          self._attempts += 1
                          if self._attempts >= self._retry_limit:
                              print(f"[pdu_text_gui_saw] Retry limit ({self._retry_limit}) exceeded for PDU 0x{self._single_packet[0]:02X}")
                              self.message_port_pub(pmt.intern("feedback"),
                                                    pmt.intern("RETRY_LIMIT_EXCEEDED"))
                              
                              # Advance the sequence ID on failure/retry limit reached
                              self._seq_id = (self._seq_id + 1) & 0xFF 

                              self._stop_event.set()
                              break

                          print(f"[pdu_text_gui_saw] TIMEOUT for 0x{self._single_packet[0]:02X} → Sync Burst + Retransmit")

                          # SEND RAW SYNC BURST FIRST
                          self._send_sync_burst()

                          # Sequence ID does NOT change; the same packet is retransmitted.

                      else:
                          # ACK received!
                          print(f"[pdu_text_gui_saw] Single PDU id=0x{self._single_packet[0]:02X} successfully ACKed.")
                          self.message_port_pub(pmt.intern("feedback"),
                                                pmt.intern("END_ACK_RECEIVED"))
                          acked = True
                          # Clean up for next message
                          self._single_packet = None
                          self._attempts = 0
                          
                          # Advance the sequence ID for the NEXT message (modulo 256)
                          self._seq_id = (self._seq_id + 1) & 0xFF 


          # -------------------------------------------------
          # ACK handler
          # -------------------------------------------------
          def _process_ack(self, msg):
              try:
                  payload = pmt.cdr(msg)
                  if not pmt.is_u8vector(payload):
                      return

                  arr = bytearray(pmt.u8vector_elements(payload))
                  # ACK format: [0xAA, ACK_ID]
                  if len(arr) < 2:
                      return
                  if arr[0] != 0xAA:
                      return

                  ack_id = arr[1]

                  with self._lock:
                      if self._single_packet is None:
                          # No packet currently being waited on
                          return

                      expected_seq_id = self._single_packet[0]

                      if ack_id == expected_seq_id:
                          self._has_acks = True
                          self._last_ack_seq = ack_id
                          
                          print(f"[pdu_text_gui_saw] ACK received for 0x{ack_id:02X}")
                          self._attempts = 0 # Reset attempts on successful ACK

              except Exception as e:
                  print(f"[pdu_text_gui_saw] ACK error: {e}")
    address: '45'
    retry_limit: '100'
    sync_bits: 1e4
    wait_time: '0.1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '48'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '45'
  states: {}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport pmt\nimport zlib\nimport os\nfrom gnuradio import gr\n\nclass crc_forwarder(gr.basic_block):\n    \"\"\"\n    CRC32 Checker + Dedup + Forwarder (Message Reassembler)\n\n    NEW:\n    - Parameter: sync_bits   → number of random bits for sync preamble.\n    - Before sending ACK: transmit a raw random-bit stream (no headers).\n    \"\"\"\n\n    def __init__(self, sync_bits=32):\n        gr.basic_block.__init__(\n            self,\n            name=\"CRC32 Dedup + Forwarder\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # ---------------------------\n        # Parameters\n        # ---------------------------\n        self.sync_bits = int(sync_bits)\n\n        # ---------------------------\n        # Internal State\n        # ---------------------------\n        self.received_ids = set()\n        self.buffers = {}\n\n        # ---------------------------\n        # Ports\n        # ---------------------------\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_out(pmt.intern(\"ack_out\"))\n        self.message_port_register_out(pmt.intern(\"sync_out\"))   # NEW: random bits\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._handle_msg)\n\n        print(f\"[CRC32] Receiver initialized (sync_bits={self.sync_bits})\")\n\n    # ----------------------------------------------------------------------\n    # Generate raw RANDOM BITSTREAM (no headers, no CRC, not packetized)\n    # ----------------------------------------------------------------------\n    def _send_sync_bits(self):\n        if self.sync_bits <= 0:\n            return\n\n        # Generate bits like: 0101010111101010...\n        bitstream = os.urandom(self.sync_bits)  # generates bytes\n        # But user wants BITSTREAM → convert each bit to 0/1 byte\n        bits = []\n        for b in bitstream:\n            for i in range(8):\n                if len(bits) >= self.sync_bits:\n                    break\n                bits.append((b >> (7 - i)) & 1)\n\n        # Send as u8vector directly\n        vec = pmt.init_u8vector(len(bits), bits)\n        msg = pmt.cons(pmt.PMT_NIL, vec)\n        self.message_port_pub(pmt.intern(\"sync_out\"), msg)\n\n        print(f\"[SYNC] Sent {len(bits)} random bits for synchronization\")\n\n    # ----------------------------------------------------------------------\n    # Main Message Handler\n    # ----------------------------------------------------------------------\n    def _handle_msg(self, msg):\n        if not pmt.is_pair(msg):\n            return\n\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 6:\n            print(\"[CRC32] Frame too short\")\n            return\n\n        sender_addr = data[0]\n        pkt_id = data[1]\n        payload = data[2:-4]\n\n        recv_crc = int.from_bytes(data[-4:], \"big\")\n        calc_crc = zlib.crc32(bytes([sender_addr, pkt_id]) + payload) & 0xFFFFFFFF\n\n        if calc_crc != recv_crc:\n            print(f\"[CRC32] FAIL (Addr 0x{sender_addr:02X}, ID {pkt_id})\")\n            return\n\n        # ---------------------------\n        # OK → First send SYNC bits\n        # ---------------------------\n        self._send_sync_bits()\n\n        print(f\"[CRC32] OK (Addr 0x{sender_addr:02X}, ID {pkt_id})\")\n\n        # ---------------------------\n        # Build ACK frame\n        # ---------------------------\n        ack_data = bytearray([sender_addr, 0xAA, pkt_id])\n        ack_crc = zlib.crc32(ack_data) & 0xFFFFFFFF\n        ack_data += ack_crc.to_bytes(4, \"big\")\n\n        ack_vec = pmt.init_u8vector(len(ack_data), list(ack_data))\n        ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)\n        self.message_port_pub(pmt.intern(\"ack_out\"), ack_pdu)\n\n        print(f\"[ACK] Sent: Addr=0x{sender_addr:02X}, ID={pkt_id}, CRC=0x{ack_crc:08X}\")\n\n        # ---------------------------\n        # Deduplication\n        # ---------------------------\n        if (sender_addr, pkt_id) in self.received_ids:\n            print(\"[Forward] Duplicate ignored\")\n            return\n\n        self.received_ids.add((sender_addr, pkt_id))\n\n        # ---------------------------\n        # END marker (empty payload)\n        # ---------------------------\n        if len(payload) == 0:\n            if sender_addr in self.buffers and self.buffers[sender_addr]:\n                full = b\"\".join(self.buffers[sender_addr])\n                out_bytes = bytes([sender_addr]) + full\n\n                out_vec = pmt.init_u8vector(len(out_bytes), list(out_bytes))\n                out_msg = pmt.cons(pmt.PMT_NIL, out_vec)\n                self.message_port_pub(pmt.intern(\"out\"), out_msg)\n\n                print(f\"[Forward] Reassembled {len(full)} bytes for Addr 0x{sender_addr:02X}\")\n            else:\n                print(f\"[Forward] END marker but empty buffer for Addr 0x{sender_addr:02X}\")\n\n            self.buffers[sender_addr] = []\n            return\n\n        # ---------------------------\n        # Normal payload append\n        # ---------------------------\n        if sender_addr not in self.buffers:\n            self.buffers[sender_addr] = []\n\n        self.buffers[sender_addr].append(payload)\n        total_len = sum(len(p) for p in self.buffers[sender_addr])\n        print(f\"[Buffer] Addr 0x{sender_addr:02X}, ID={pkt_id} → {len(payload)} bytes (total {total_len})\")\n\n"
    sync_bits: 1e4
  states: {state: disabled}
- name: epy_block_4_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      import zlib
      import time
      import os
      from gnuradio import gr

      class crc_forwarder_immediate(gr.basic_block):
          """
          CRC32 Forwarder (Immediate Mode)
          - Input : [sender_addr | payload | crc32]
          - Output: [sender_addr | payload] (Forwarded immediately)
          - ACK   : Immediate [sender_addr | 0xAA | crc32]
          - Note  : Calculates and appends CRC to ACK internally.
          """

          def __init__(self, retry_limit=1, sync_len=1000):
              gr.basic_block.__init__(
                  self,
                  name="CRC32 Forwarder (Immediate + CRC)",
                  in_sig=[],
                  out_sig=[]
              )

              self.retry_limit = max(1, int(retry_limit))
              self.sync_len = int(sync_len)  # Number of sync bytes
              
              # Ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("ack_out"))

              self.set_msg_handler(pmt.intern("in"), self._handle_msg)

              print(f"[CRC32] Receiver init (retries={self.retry_limit}, sync_len={self.sync_len})")

          def _send_ack(self, sender_addr):
              """
              Sends an ACK with CRC32 manually calculated and appended.
              Modified to use the structure: [sender_addr | 0xAA | crc32]
              """
              
              # 1. Send Synchronization/Wake-up Bytes (if configured)
              if self.sync_len > 0:
                  noise_data = os.urandom(self.sync_len)
                  noise_vec = pmt.init_u8vector(len(noise_data), list(noise_data))
                  noise_pdu = pmt.cons(pmt.PMT_NIL, noise_vec)
                  
                  self.message_port_pub(pmt.intern("ack_out"), noise_pdu)
                  
                  # Small delay to ensure sync bytes clear before ACK follows
                  time.sleep(0.01)  

              # 2. Construct ACK Payload: [Address] [0xAA] 
              # This matches the structural start of the batch forwarder's ACK without the sequence ID.
              ack_data = bytearray([sender_addr, 0xAA]) # <--- MODIFIED LINE
              
              # 3. Calculate CRC32 (Same method as original code)
              ack_crc = zlib.crc32(ack_data) & 0xFFFFFFFF
              
              # 4. Append CRC bytes (Big Endian)
              ack_data += ack_crc.to_bytes(4, 'big')

              ack_vec = pmt.init_u8vector(len(ack_data), list(ack_data))
              ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)

              # 5. Send ACK (with retries if configured)
              for i in range(self.retry_limit):
                  self.message_port_pub(pmt.intern("ack_out"), ack_pdu)
                  if self.retry_limit > 1:
                      time.sleep(0.005) 
              
              print(f"[ACK] Sent for 0x{sender_addr:02X} (CRC={ack_crc:08X})")

          def _handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return

              data = bytearray(pmt.u8vector_elements(vec))
              
              # Minimum size: Addr(1) + CRC(4) = 5 bytes
              if len(data) < 5:
                  print("[CRC32] Frame too short")
                  return

              # --- PARSING ---
              sender_addr = data[0]
              payload = data[1:-4]
              recv_crc = int.from_bytes(data[-4:], "big")

              # --- CRC CHECK ---
              calc_crc = zlib.crc32(bytes([sender_addr]) + payload) & 0xFFFFFFFF

              if calc_crc != recv_crc:
                  print(f"[CRC32] FAIL (Addr=0x{sender_addr:02X})")
                  return

              print(f"[CRC32] OK (Addr=0x{sender_addr:02X}, Len={len(payload)})")

              # --- SEND ACK (With CRC) ---
              self._send_ack(sender_addr)

              # --- FORWARD MESSAGE ---
              # Output format: [Address] + [Payload]
              forward_bytes = bytes([sender_addr]) + payload

              out_vec = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))
              out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
              self.message_port_pub(pmt.intern("out"), out_msg)

              print(f"[Forward] Message sent ({len(forward_bytes)} bytes)")
    retry_limit: '2'
    sync_len: '1000'
  states: {state: disabled}
- name: epy_block_4_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      import zlib
      import time
      import os
      from gnuradio import gr

      class crc_forwarder_unorder(gr.basic_block):
          """
          CRC32 Checker + Unordered Forwarder
          - Input : [sender_addr | seq_id | payload | crc32]
          - Output: [sender_addr | payload] (Forwarded IMMEDIATELY and UNORDERED)
          - ACKs all packets with valid CRC.
          """

          def __init__(self, retry_limit=1, ack_batch_size=5, sync_len=1000):
              gr.basic_block.__init__(
                  self,
                  name="CRC32 Unordered Forwarder",
                  in_sig=[],
                  out_sig=[]
              )

              self.retry_limit = max(1, int(retry_limit))
              self.ack_batch_size = max(1, int(ack_batch_size))
              self.sync_len = int(sync_len)  # Number of sync bytes
              
              # We no longer need the full buffer or expected_seq for forwarding.
              # We only keep received_ids for simple packet deduplication within a recent window.
              self.ack_queue = []
              # Stores every received ID for deduplication: {sender_addr: set(seq_ids)}
              self.received_ids = {} 
              # Stores the highest seen sequence ID for each sender to manage the deduplication window
              self.highest_seq = {} 

              # Ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("ack_out"))

              self.set_msg_handler(pmt.intern("in"), self._handle_msg)

              print(f"[CRC32] Receiver init (retries={self.retry_limit}, batch={self.ack_batch_size}, sync_len={self.sync_len})")

          def _flush_ack_queue(self):
              """Sends sync bytes (if any), then flushes all queued ACKs."""
              if not self.ack_queue:
                  return

              print(f"[ACK] Batch threshold reached. Flushing {len(self.ack_queue)} ACKs...")

              # 1. Send Synchronization/Wake-up Bytes (if configured)
              if self.sync_len > 0:
                  noise_data = os.urandom(self.sync_len)
                  noise_vec = pmt.init_u8vector(len(noise_data), list(noise_data))
                  noise_pdu = pmt.cons(pmt.PMT_NIL, noise_vec)
                  self.message_port_pub(pmt.intern("ack_out"), noise_pdu)
                  time.sleep(0.01)  

              # 2. Send all queued ACKs
              for ack_pdu in self.ack_queue:
                  for i in range(self.retry_limit):
                      self.message_port_pub(pmt.intern("ack_out"), ack_pdu)
                      time.sleep(0.005)  
              
              # Clear the queue
              self.ack_queue = []
              print("[ACK] Batch flush complete.")
          
          def _clean_dedup_set(self, addr, pkt_id):
              """Keeps the received_ids set from growing indefinitely by only tracking IDs near the highest seen ID."""
              if addr not in self.received_ids:
                  self.received_ids[addr] = set()
                  self.highest_seq[addr] = pkt_id
                  return

              current_highest = self.highest_seq[addr]
              
              # Check if the new ID is significantly greater than the current highest, indicating a wrap or large jump
              if (pkt_id > current_highest) and (pkt_id - current_highest < 128):
                  self.highest_seq[addr] = pkt_id
              # Handle 8-bit wrap around (e.g., 255 -> 1)
              elif (current_highest > 128) and (pkt_id < 128) and (current_highest - pkt_id > 128):
                  self.highest_seq[addr] = pkt_id

              # Simple cleanup: clear IDs that are 128 behind the current highest (assuming 8-bit ID range 1-255)
              # We use a window of about 128 to ensure we catch most duplicates while freeing up old IDs.
              old_cutoff = (self.highest_seq[addr] - 128) & 0xFF
              
              ids_to_remove = []
              for seq_id in self.received_ids[addr]:
                  # This is a robust check for checking if seq_id is older than old_cutoff, considering wrap-around
                  if (seq_id != old_cutoff) and (((seq_id - old_cutoff) & 0xFF) < 128):
                      ids_to_remove.append(seq_id)

              for seq_id in ids_to_remove:
                  self.received_ids[addr].discard(seq_id)

          def _handle_msg(self, msg):
              if not pmt.is_pair(msg):
                  return
              vec = pmt.cdr(msg)
              if not pmt.is_u8vector(vec):
                  return

              data = bytearray(pmt.u8vector_elements(vec))
              if len(data) < 6:
                  print("[CRC32] Frame too short")
                  return

              sender_addr = data[0]
              pkt_id = data[1]
              payload = data[2:-4]
              recv_crc = int.from_bytes(data[-4:], "big")

              # CRC check
              calc_crc = zlib.crc32(bytes([sender_addr, pkt_id]) + payload) & 0xFFFFFFFF
              if calc_crc != recv_crc:
                  print(f"[CRC32] FAIL (Addr=0x{sender_addr:02X}, ID=0x{pkt_id:02X})")
                  return

              print(f"[CRC32] OK (Addr=0x{sender_addr:02X}, ID=0x{pkt_id:02X})")
              
              # Initialize state for new sender address
              if sender_addr not in self.received_ids:
                  self.received_ids[sender_addr] = set()
                  self.highest_seq[sender_addr] = 0
                  
              # --- Build ACK & Queue It (ACK always sent if CRC passes) ---
              ack_data = bytearray([sender_addr, 0xAA, pkt_id])
              ack_crc = zlib.crc32(ack_data) & 0xFFFFFFFF
              ack_data += ack_crc.to_bytes(4, 'big')

              ack_vec = pmt.init_u8vector(len(ack_data), list(ack_data))
              ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)

              self.ack_queue.append(ack_pdu)
              print(f"[ACK] Queued ({len(self.ack_queue)}/{self.ack_batch_size})")

              # Check threshold
              if len(self.ack_queue) >= self.ack_batch_size:
                  self._flush_ack_queue()

              # Dedup Check
              if pkt_id in self.received_ids[sender_addr]:
                  print(f"[Forward] Duplicate packet ID=0x{pkt_id:02X}, ignored payload")
                  return

              # Mark as received
              self.received_ids[sender_addr].add(pkt_id)
              
              # Clean up old entries in the dedup set
              self._clean_dedup_set(sender_addr, pkt_id)

              # --- IMMEDIATE UNORDERED FORWARDING (New Requirement) ---
              full_payload_segment = payload
              forward_bytes = bytes([sender_addr]) + full_payload_segment

              out_vec = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))
              out_msg = pmt.cons(pmt.PMT_NIL, out_vec)
              self.message_port_pub(pmt.intern("out"), out_msg)

              print(f"[Forward] Packet forwarded immediately (ID=0x{pkt_id:02X}, {len(full_payload_segment)} bytes).")
    ack_batch_size: '1'
    retry_limit: '2'
    sync_len: '1000'
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad

      class aes_encrypt(gr.basic_block):
          """
          AES Encryption Block
          - Encrypts PDUs using AES-128-CBC
          - Key & IV fixed for demo (replace with secure exchange in real systems)
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Encrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  enc_data = cipher.encrypt(pad(data, AES.block_size))

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(enc_data), list(enc_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Cryptodome.Cipher import AES
      from Cryptodome.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,1,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: Frequency Spectrum of Tx ACK
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum of ACK
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX-SPECTRUM
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    name: RX-SPECTRUM of ACK
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 2.4e9
    gain: '50'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 2.5e9
    gain: '50'
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 2.4e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 2.5e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: gui
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: gui
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, epy_block_0, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_0, out, epy_block_5_0, in]
- [epy_block_0_1_0, dest_addr, epy_block_0, addr_in]
- [epy_block_0_1_0, out, epy_block_2_0_0, in]
- [epy_block_2_0_0, feedback, epy_block_0_1_0, feedback]
- [epy_block_2_0_0, out, digital_crc_append_0, in]
- [epy_block_3, out, epy_block_4_0, in]
- [epy_block_3, out, epy_block_4_0_0, in]
- [epy_block_3, out, epy_block_4_0_0_0, in]
- [epy_block_3_0, out, epy_block_2_0_0, ack_in]
- [epy_block_4_0, ack_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_4_0, out, virtual_sink_2, '0']
- [epy_block_4_0_0, ack_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_4_0_0, out, virtual_sink_2, '0']
- [epy_block_4_0_0_0, ack_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_4_0_0_0, out, virtual_sink_2, '0']
- [epy_block_5_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_6, out, epy_block_3, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, in]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_6, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [virtual_source_3, '0', epy_block_0_1_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
