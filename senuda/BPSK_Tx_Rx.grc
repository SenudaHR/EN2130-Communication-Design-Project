options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bpsk_stage6
    output_language: python
    title: bpsk_stage6
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: arity
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '29'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '1'
  states: {}
- name: file_name
  id: variable_qtgui_entry
  parameters:
    type: string
    value: /home/prabathbk/Desktop/image1.jpg
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '1'
    option1: '-1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0 + 0.0j, ]'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: time_offset
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: timing_loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: bpsk
    modulus: '2'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '254'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/mihiran/Documents/GNU_Radio/Project/output.txt
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./output.tmp
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/mihiran/Documents/GNU_Radio/Project/output.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mihiran/Documents/GNU_Radio/Project/test
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/vboxuser/Downloads/tx.jpg
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1,0]*4'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"11100001010110101110100010010011"'
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '1'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    osps: '1'
    pfb_mf_taps: '[12]'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: file_name
    Pkt_len: '60'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.c_len = len (self.char_list)\n        # print (self.c_len)\n        self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.f_len = len (self.filler)\n\n    def work(self, input_items, output_items):\n\n        if (self.state == 0):\n            # idle\n            return (0)\n\n        elif (self.state == 1):\n            # send preamble\n            if (self._debug):\n                print (\"state = 1\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 64):\n                self.pre_count = 0\n                self.state = 2      # send msg\n            return (self.c_len)\n\n        elif (self.state == 2):\n            while (not (self._eof)):\n                buff = self.f_in.read (self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 3      # send file name\n                    self.pre_count = 0\n                    break\n                # convert to Base64\n                encoded = base64.b64encode (buff)\n                e_len = len(encoded)\n                if (self._debug):\n                    print ('b64 length =', e_len)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key0,   # Key of the tag\n                    val0    # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                return (e_len)\n\n        elif (self.state == 3):\n            # send file name\n            fn_len = len (self.FileName)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(fn_len+8)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += (fn_len+8)\n            i = 0\n            while (i < 8):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            j = 0\n            while (i < (fn_len+8)):\n                output_items[0][i] = ord(self.FileName[j])\n                i += 1\n                j += 1\n            self.state = 4\n            return (fn_len+8)\n\n        elif (self.state == 4):\n            # send post filler\n            if (self._debug):\n                print (\"state = 4\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.f_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.f_len\n            i = 0\n            while (i < self.f_len):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 16):\n                self.pre_count = 0\n                self.state = 0      # idle\n            return (self.f_len)\n\n        return (0)\n\n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    FileName: '"/home/vboxuser/Downloads/tx.jpg"'
    Pkt_len: '60'
    _source_code: "\"\"\"\nEmbedded Python Block: File Source to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\nimport os.path\nimport sys\nimport base64\n\n\"\"\"\nState definitions\n    0   idle\n    1   send preamble\n    2   send file data\n    3   send file name\n    4   send post filler\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, FileName='None', Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name='EPB: File Source to Tagged Stream',\n            in_sig=None,\n            out_sig=[np.uint8])\n        self.FileName = FileName\n        self.Pkt_len = Pkt_len\n        self.state = 0      # idle state\n        self.pre_count = 0\n        self.indx = 0\n        self._debug = 0     # debug\n        self.data = \"\"\n\n        if (os.path.exists(self.FileName)):\n            # open input file\n            self.f_in = open (self.FileName, 'rb')\n            self._eof = False\n            if (self._debug):\n                print (\"File name:\", self.FileName)\n            self.state = 1\n        else:\n            print(self.FileName, 'does not exist')\n            self._eof = True\n            self.state = 0\n\n        self.char_list = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.c_len = len (self.char_list)\n        # print (self.c_len)\n        self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]\n        self.f_len = len (self.filler)\n\n    def work(self, input_items, output_items):\n\n        if (self.state == 0):\n            # idle\n            return (0)\n\n        elif (self.state == 1):\n            # send preamble\n            if (self._debug):\n                print (\"state = 1\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.c_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.c_len\n            i = 0\n            while (i < self.c_len):\n                output_items[0][i] = self.char_list[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 64):\n                self.pre_count = 0\n                self.state = 2      # send msg\n            return (self.c_len)\n\n        elif (self.state == 2):\n            while (not (self._eof)):\n                buff = self.f_in.read (self.Pkt_len)\n                b_len = len(buff)\n                if b_len == 0:\n                    print ('End of file')\n                    self._eof = True\n                    self.f_in.close()\n                    self.state = 3      # send file name\n                    self.pre_count = 0\n                    break\n                # convert to Base64\n                encoded = base64.b64encode (buff)\n                e_len = len(encoded)\n                if (self._debug):\n                    print ('b64 length =', e_len)\n                key0 = pmt.intern(\"packet_len\")\n                val0 = pmt.from_long(e_len)\n                self.add_item_tag(0, # Write to output port 0\n                    self.indx,   # Index of the tag\n                    key0,   # Key of the tag\n                    val0    # Value of the tag\n                    )\n                self.indx += e_len\n                i = 0\n                while (i < e_len):\n                    output_items[0][i] = encoded[i]\n                    i += 1\n                return (e_len)\n\n        elif (self.state == 3):\n            # send file name\n            fn_len = len (self.FileName)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(fn_len+8)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += (fn_len+8)\n            i = 0\n            while (i < 8):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            j = 0\n            while (i < (fn_len+8)):\n                output_items[0][i] = ord(self.FileName[j])\n                i += 1\n                j += 1\n            self.state = 4\n            return (fn_len+8)\n\n        elif (self.state == 4):\n            # send post filler\n            if (self._debug):\n                print (\"state = 4\", self.pre_count)\n            key1 = pmt.intern(\"packet_len\")\n            val1 = pmt.from_long(self.f_len)\n            self.add_item_tag(0, # Write to output port 0\n                self.indx,   # Index of the tag\n                key1,   # Key of the tag\n                val1    # Value of the tag\n                )\n            self.indx += self.f_len\n            i = 0\n            while (i < self.f_len):\n                output_items[0][i] = self.filler[i]\n                i += 1\n            self.pre_count += 1\n            if (self.pre_count > 16):\n                self.pre_count = 0\n                self.state = 0      # idle\n            return (self.f_len)\n\n        return (0)\n\n"
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Rx Bits
    label2: Diff
    label3: Tx Bits
    name: ''
    nconnections: '3'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '200'
    center_freq: 2.7e9
    gain: '40'
    samp_rate: '520834'
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '200'
    center_freq: 2.7e9
    gain: '40'
    samp_rate: '520834'
    type: fc32
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 5e9
    samp_rate: 32e5
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: r1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '"xmt_sig"'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '"xmt_sig"'
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r1
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_1, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_float_to_uchar_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', channels_channel_model_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_map_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, '0', digital_constellation_modulator_0, '0']
- [epy_block_0_0, '0', digital_crc32_bb_0, '0']
- [soapy_bladerf_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_0, '0', virtual_sink_1, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [virtual_source_2, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
