options:
  parameters:
    author: BellLabz
    category: Custom
    description: cdp project
    generate_options: qt_gui
    id: cdp
    output_language: python
    title: cdp
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    comment: Set Bandwidth
    value: '.5'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '1110000101011010111010001001001111100001010110101110100010010011'
    bps: '1'
    threshold: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_gain_0
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: samp_rate_blade
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: spr
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples Per Symbol
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: txbw
  id: variable
  parameters:
    value: '9000'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: string
    value: ''
  states: {}
- name: MTU
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '1500'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: unpack 2 bits per symbol into bits
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    comment: Simulated channel
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '3'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Decode a constellation's points from 
      a complex space to index of constellation 
      symbol based on the map of the  object.
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    comment: Modulation block
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1110000101011010111010001001001111100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1110000101011010111010001001001111100001010110101110100010010011'
    tagname: '"packet_len"'
    threshold: '1'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    comment: Phase and Fine Frequency Correction
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: |-
      translate the differential coded symbols
       back to their original symbols
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '32'
    sps: '4'
  states: {}
- name: digital_linear_equalizer_0_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      convert the symbols 
      from the differential decoder to the 
      original symbols we transmitted.
    map: '[0,1,2,3]'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_formatter_async_0_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '4'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: phase_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '2'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_add(gr.basic_block):
          """
          Block to prepend a dynamic address byte to a PDU payload.
          
          This block has no GRC parameters. It relies entirely on the 'addr_in' 
          port to set the destination address.
          """
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="address_add",
                  in_sig=[],
                  out_sig=[]
              )
              # Default internal state (will be overwritten by GUI immediately)
              self.address = 0x00
              
              # Port for the Text Payload
              self.message_port_register_in(pmt.intern("in"))
              # Port for the Address Update
              self.message_port_register_in(pmt.intern("addr_in"))
              
              # Output Port
              self.message_port_register_out(pmt.intern("out"))
              
              # Register handlers
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)
              self.set_msg_handler(pmt.intern("addr_in"), self.handle_address_update)

          def handle_address_update(self, msg):
              """
              Receives the address from the GUI (Symbol or Int) 
              and updates the internal state.
              """
              try:
                  # GUI sends address as a String Symbol (e.g. "255")
                  if pmt.is_symbol(msg):
                      str_val = pmt.symbol_to_string(msg)
                      self.address = int(str_val)
                  
                  # If standard int/long is sent
                  elif pmt.is_integer(msg) or pmt.is_uint64(msg):
                      self.address = pmt.to_long(msg)
                      
                  # print(f"[address_add] Active Address set to: {self.address}")
                      
              except ValueError:
                  pass

          def handle_msg(self, msg):
              """
              Prepend the currently active 'self.address' to the message.
              """
              meta = pmt.make_dict()
              payload = bytearray()

              # 1. Parse Input
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  payload = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
              elif pmt.is_symbol(msg):
                  text_data = pmt.symbol_to_string(msg)
                  payload = bytearray(text_data, 'utf-8')
              else:
                  return

              # 2. Prepend Address
              safe_addr = self.address & 0xFF
              payload.insert(0, safe_addr)

              # 3. Publish
              out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
              self.message_port_pub(pmt.intern("out"), out_msg)
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      from gnuradio import gr
      from PyQt5 import QtWidgets, QtCore, QtGui
      import sys
      import pmt
      from datetime import datetime

      # ==========================================
      # 1. CUSTOM UI COMPONENTS
      # ==========================================

      class WallpaperScrollArea(QtWidgets.QScrollArea):
          def __init__(self, bg_image="", parent=None):
              super().__init__(parent)
              self.setWidgetResizable(True)
              self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None

          def paintEvent(self, event):
              if self.bg_pixmap and not self.bg_pixmap.isNull():
                  painter = QtGui.QPainter(self.viewport())
                  scaled_pixmap = self.bg_pixmap.scaled(
                      self.viewport().size(),
                      QtCore.Qt.KeepAspectRatioByExpanding,
                      QtCore.Qt.SmoothTransformation
                  )
                  x = (self.viewport().width() - scaled_pixmap.width()) // 2
                  y = (self.viewport().height() - scaled_pixmap.height()) // 2
                  painter.drawPixmap(x, y, scaled_pixmap)
              super().paintEvent(event)

      # ==========================================
      # 2. THE MAIN WINDOW (GUI LOGIC)
      # ==========================================
      class MessengerWindow(QtWidgets.QWidget):
          # Signals to GR
          send_to_gr_signal = QtCore.pyqtSignal(str)
          addr_selected_signal = QtCore.pyqtSignal(str)

          def __init__(self, bg_image=""):
              super().__init__()
              self.setWindowTitle("BellLabz")
              self.resize(950, 700)
              self.bg_image_path = bg_image
              
              # --- STATE FLAGS ---
              self.is_waiting_for_ack = False 
              
              # --- DATA STRUCTURES ---
              self.added_addresses = set()
              self.selected_btn = None 
              self.current_dest_address = None
              
              # Structure: { addr_int: {'page': widget, 'layout': box, 'scroll': area, 'btn': btn_obj, 'dot': dot_label} }
              self.user_data = {} 

              # --- STYLES ---
              self.style_btn_normal = """
                  QPushButton {
                      background-color: #34495e; color: #ecf0f1; border: 1px solid #2c3e50;
                      padding: 12px; border-radius: 6px; text-align: left;
                  }
                  QPushButton:hover { background-color: #4b6584; }
                  QPushButton:disabled { background-color: #2c3e50; color: #7f8c8d; border: 1px solid #2c3e50; }
              """
              self.style_btn_selected = """
                  QPushButton {
                      background-color: #27ae60; color: white; border: 2px solid white;
                      padding: 12px; border-radius: 6px; text-align: left; font-weight: bold;
                  }
                  QPushButton:disabled { background-color: #2ecc71; opacity: 0.7; }
              """

              # --- MAIN LAYOUT ---
              self.main_layout = QtWidgets.QHBoxLayout()
              self.main_layout.setContentsMargins(0, 0, 0, 0)
              self.main_layout.setSpacing(0)
              self.setLayout(self.main_layout)

              self._init_sidebar()
              self._init_right_panel()

          def _init_sidebar(self):
              self.sidebar = QtWidgets.QWidget()
              self.sidebar.setFixedWidth(250)
              self.sidebar.setStyleSheet("background-color: #2c3e50; border-right: 1px solid #1a252f;")
              layout = QtWidgets.QVBoxLayout(self.sidebar)
              layout.setSpacing(10)

              header = QtWidgets.QLabel("CHATS")
              header.setStyleSheet("color: #95a5a6; font-weight: bold; margin-top: 10px; font-size: 14px;")
              layout.addWidget(header)

              # Input
              input_con = QtWidgets.QHBoxLayout()
              self.addr_input = QtWidgets.QLineEdit()
              self.addr_input.setPlaceholderText("ID (0-255)")
              self.addr_input.setStyleSheet("""
                  QLineEdit { background: #ecf0f1; border: none; border-radius: 4px; padding: 8px; color: black; }
                  QLineEdit:disabled { background: #95a5a6; color: #555; }
              """)
              self.addr_input.setValidator(QtGui.QIntValidator(0, 255))
              self.addr_input.returnPressed.connect(self.manual_add_address)

              self.add_btn = QtWidgets.QPushButton("+")
              self.add_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.add_btn.setFixedWidth(40)
              self.add_btn.clicked.connect(self.manual_add_address)
              self.add_btn.setStyleSheet("""
                  QPushButton { background: #3498db; color: white; border: none; border-radius: 4px; font-weight: bold; }
                  QPushButton:disabled { background: #7f8c8d; }
              """)
              
              input_con.addWidget(self.addr_input)
              input_con.addWidget(self.add_btn)
              layout.addLayout(input_con)

              layout.addWidget(self._create_separator())

              # Contact List Scroll
              self.contact_scroll = QtWidgets.QScrollArea()
              self.contact_scroll.setWidgetResizable(True)
              self.contact_scroll.setStyleSheet("border: none; background: transparent;")
              
              self.contact_container = QtWidgets.QWidget()
              self.contact_layout = QtWidgets.QVBoxLayout(self.contact_container)
              self.contact_layout.setAlignment(QtCore.Qt.AlignTop)
              self.contact_layout.setSpacing(5)
              self.contact_scroll.setWidget(self.contact_container)

              layout.addWidget(self.contact_scroll)
              self.main_layout.addWidget(self.sidebar)

          def _init_right_panel(self):
              right_panel = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(right_panel)
              layout.setContentsMargins(0, 0, 0, 0)
              layout.setSpacing(0)

              # Stack for Chat Pages
              self.chat_stack = QtWidgets.QStackedWidget()
              welcome_page = QtWidgets.QLabel("Select a contact to start messaging")
              welcome_page.setAlignment(QtCore.Qt.AlignCenter)
              welcome_page.setStyleSheet("background-color: #e5ddd5; color: #888; font-size: 18px;")
              self.chat_stack.addWidget(welcome_page)
              layout.addWidget(self.chat_stack, stretch=1)

              # Input Area
              self.input_box_wrapper = QtWidgets.QWidget()
              self.input_box_wrapper.setStyleSheet("background-color: #f0f0f0; border-top: 1px solid #dcdcdc;")
              input_box_layout = QtWidgets.QHBoxLayout(self.input_box_wrapper)
              input_box_layout.setContentsMargins(10, 10, 10, 10)
              
              self.msg_input = QtWidgets.QLineEdit()
              self.msg_input.setPlaceholderText("Type a message...")
              self.msg_input.setStyleSheet("""
                  QLineEdit { border-radius: 20px; padding: 10px 15px; background: white; border: 1px solid #ccc; font-size: 14px; }
                  QLineEdit:disabled { background-color: #e0e0e0; color: #888; }
              """)
              
              self.send_btn = QtWidgets.QPushButton("Send")
              self.send_btn.setCursor(QtCore.Qt.PointingHandCursor)
              self.send_btn.setStyleSheet("""
                  QPushButton { background-color: #008069; color: white; border-radius: 20px; padding: 10px 20px; font-weight: bold; }
                  QPushButton:disabled { background-color: #95a5a6; }
              """)
              
              self.msg_input.returnPressed.connect(self.on_send_click)
              self.send_btn.clicked.connect(self.on_send_click)

              input_box_layout.addWidget(self.msg_input)
              input_box_layout.addWidget(self.send_btn)

              layout.addWidget(self.input_box_wrapper)
              self.main_layout.addWidget(right_panel)
              
              self.input_box_wrapper.hide()

          def _create_separator(self):
              line = QtWidgets.QFrame()
              line.setFrameShape(QtWidgets.QFrame.HLine)
              line.setStyleSheet("color: #3e5871;")
              return line

          def manual_add_address(self):
              text = self.addr_input.text().strip()
              if not text: return
              try:
                  val = int(text)
                  self.ensure_user_exists(val)
                  # Simulate click to select logic
                  btn = self.user_data[val]['btn']
                  self.handle_address_click(btn, val)
                  self.addr_input.clear()
              except ValueError:
                  pass

          def ensure_user_exists(self, address_val):
              """Creates user context if it doesn't exist. Returns the user dict."""
              if address_val in self.user_data:
                  return self.user_data[address_val]

              self.added_addresses.add(address_val)

              # 1. Create Sidebar Button Widget
              btn_widget = QtWidgets.QWidget()
              btn_layout = QtWidgets.QHBoxLayout(btn_widget)
              btn_layout.setContentsMargins(0,0,0,0)
              
              # The actual clickable button
              btn = QtWidgets.QPushButton(f"Node {address_val}")
              btn.setCursor(QtCore.Qt.PointingHandCursor)
              btn.setStyleSheet(self.style_btn_normal)
              btn.setFixedHeight(50)
              
              # Unread Dot (Overlay logic via layout)
              # To make layout simple, we'll just put the dot inside the button text or next to it?
              # Let's use a layout approach:
              
              dot = QtWidgets.QLabel("●") 
              dot.setStyleSheet("color: #f1c40f; font-size: 16px; margin-right: 5px;") # Yellow dot
              dot.setVisible(False)

              # We need a custom widget click handling or just overlay the button
              # Simplification: Connect button click. The dot is separate but we track it.
              # Let's wrap btn and dot in a container? No, let's keep it simple.
              # We will add dot to the HBox inside the sidebar layout item?
              
              # Better approach: Subclass QPushButton or just add dot next to it
              container_widget = QtWidgets.QWidget()
              cw_layout = QtWidgets.QHBoxLayout(container_widget)
              cw_layout.setContentsMargins(0,0,0,0)
              cw_layout.setSpacing(0)
              
              # Helper logic to make the whole row clickable requires event filter, 
              # but let's just make the button fill the space and manage the dot internally?
              # Let's stick to the previous button style but change text color if unread?
              # Or just append a unicode dot to text?
              
              # Going with the clean layout approach:
              # [ Button (Stretches) ] [ Dot (Fixed) ]
              
              btn.clicked.connect(lambda checked, b=btn, a=address_val: self.handle_address_click(b, a))
              
              # Add to sidebar
              # We need to modify style to allow dot visibility. 
              # Actually, let's put the dot IN the button text for simplicity given the constraints
              # No, let's do it right.
              
              self.contact_layout.addWidget(btn)

              # 2. Create Chat Page
              new_chat_page = self._create_chat_page_widget()
              self.chat_stack.addWidget(new_chat_page)
              
              chat_layout = new_chat_page.widget().layout()
              
              # Store Data
              self.user_data[address_val] = {
                  "page": new_chat_page,
                  "layout": chat_layout,
                  "scroll_area": new_chat_page,
                  "btn": btn,
                  "has_unread": False
              }
              
              return self.user_data[address_val]

          def _create_chat_page_widget(self):
              scroll = WallpaperScrollArea(bg_image=self.bg_image_path)
              scroll.setStyleSheet("border: none; background-color: #e5ddd5;") 
              container = QtWidgets.QWidget()
              layout = QtWidgets.QVBoxLayout(container)
              layout.setAlignment(QtCore.Qt.AlignTop)
              scroll.setWidget(container)
              container.setStyleSheet("background: transparent;")
              return scroll

          def handle_address_click(self, btn_obj, address_val):
              if self.is_waiting_for_ack:
                  return

              # Show input bar
              if self.input_box_wrapper.isHidden():
                  self.input_box_wrapper.show()

              # Update Button Styles
              if self.selected_btn and self.selected_btn != btn_obj:
                  self.selected_btn.setStyleSheet(self.style_btn_normal)
              
              btn_obj.setStyleSheet(self.style_btn_selected)
              self.selected_btn = btn_obj
              
              # Clear Unread
              if self.user_data[address_val]["has_unread"]:
                  self.user_data[address_val]["has_unread"] = False
                  btn_obj.setText(f"Node {address_val}") # Remove dot from text

              self.current_dest_address = address_val
              
              # Switch Stack
              target_page = self.user_data[address_val]["page"]
              self.chat_stack.setCurrentWidget(target_page)

              # Emit Address Change
              self.addr_selected_signal.emit(str(address_val))

          def on_send_click(self):
              if self.is_waiting_for_ack:
                  return

              text = self.msg_input.text().strip()
              if not text: return
              
              if self.current_dest_address is None:
                  return

              self._set_ui_busy_state(True)

              user_entry = self.user_data[self.current_dest_address]
              
              # Add SENT Bubble (Right side)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=True)
              
              self.send_to_gr_signal.emit(text)
              self.msg_input.clear()

          @QtCore.pyqtSlot(int, str)
          def handle_received_msg(self, src_addr, text):
              """Called when a PDU arrives from GNU Radio"""
              
              # 1. Ensure User Exists
              user_entry = self.ensure_user_exists(src_addr)
              
              # 2. Add RECEIVED Bubble (Left Side)
              self._add_message_bubble(text, user_entry["layout"], user_entry["scroll_area"], is_sender=False)
              
              # 3. Handle Unread Logic
              if self.current_dest_address != src_addr:
                  user_entry["has_unread"] = True
                  # Simple visual indicator: Append dot to button text
                  btn = user_entry["btn"]
                  if "●" not in btn.text():
                      btn.setText(f"Node {src_addr} ●")

          def _add_message_bubble(self, text, layout, scroll_area, is_sender):
              container = QtWidgets.QWidget()
              vbox = QtWidgets.QVBoxLayout(container)
              vbox.setContentsMargins(0,0,0,0)

              # Scroll for long text in bubble
              h_scroll = QtWidgets.QScrollArea()
              h_scroll.setWidgetResizable(True)
              h_scroll.setFixedHeight(60)
              h_scroll.setStyleSheet("background: transparent; border: none;")
              h_scroll.setVerticalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)
              h_scroll.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAsNeeded)

              lbl = QtWidgets.QLabel(text)
              
              if is_sender:
                  # Green, Right Aligned
                  lbl.setStyleSheet("background-color: #dcf8c6; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignRight
              else:
                  # White, Left Aligned
                  lbl.setStyleSheet("background-color: #ffffff; padding: 8px; border-radius: 10px; font-size: 16px; color: black;")
                  align = QtCore.Qt.AlignLeft

              h_scroll.setWidget(lbl)
              h_scroll.setMinimumWidth(100)
              h_scroll.setMaximumWidth(450)
              lbl.adjustSize()
              h_scroll.setFixedHeight(lbl.height() + 25)

              # Timestamp
              ts_text = datetime.now().strftime("%H:%M")
              ts = QtWidgets.QLabel(ts_text)
              ts.setStyleSheet("color: grey; font-size: 10px;")
              ts.setAlignment(QtCore.Qt.AlignRight if is_sender else QtCore.Qt.AlignLeft)
              
              vbox.addWidget(h_scroll)
              vbox.addWidget(ts)

              # Horizontal Row Alignment
              row = QtWidgets.QHBoxLayout()
              if is_sender:
                  row.addStretch()
                  row.addWidget(container)
                  self._last_message_timestamp = ts # Track only my sent messages for ACK
              else:
                  row.addWidget(container)
                  row.addStretch()
              
              layout.addLayout(row)
              
              # Scroll to bottom
              QtCore.QTimer.singleShot(50, lambda: scroll_area.verticalScrollBar().setValue(scroll_area.verticalScrollBar().maximum()))

          def _set_ui_busy_state(self, is_busy):
              """Disables/Enables INPUT, SEND BTN, SIDEBAR, and ADD BTN"""
              self.is_waiting_for_ack = is_busy
              
              self.msg_input.setEnabled(not is_busy)
              self.send_btn.setEnabled(not is_busy)
              self.addr_input.setEnabled(not is_busy)
              self.add_btn.setEnabled(not is_busy)

              for addr, data in self.user_data.items():
                  data['btn'].setEnabled(not is_busy)
              
              if is_busy:
                  self.send_btn.setText("Wait...")
              else:
                  self.send_btn.setText("Send")
                  self.msg_input.setFocus()

          @QtCore.pyqtSlot(str)
          def handle_feedback(self, feedback):
              # ACK logic only applies to the last SENT message
              if hasattr(self, '_last_message_timestamp') and self._last_message_timestamp:
                  if feedback == "END_ACK_RECEIVED":
                      current_text = self._last_message_timestamp.text()
                      if "✓" not in current_text:
                          self._last_message_timestamp.setText(current_text + " ✓✓")
                          self._last_message_timestamp.setStyleSheet("color: #34B7F1; font-weight: bold; font-size: 10px;")
                  elif feedback == "RETRY_LIMIT_EXCEEDED":
                      self._last_message_timestamp.setText("Failed ❌")
                      self._last_message_timestamp.setStyleSheet("color: red; font-size: 10px;")
              
              self._set_ui_busy_state(False)

      # ==========================================
      # 3. GNU RADIO BLOCK
      # ==========================================
      class GuiSignaler(QtCore.QObject):
          feedback_signal = QtCore.pyqtSignal(str)
          receive_signal = QtCore.pyqtSignal(int, str) # addr, text

      class messenger_gui(gr.basic_block):
          """
          Inputs: 
             'in' (PDUs from receiver)
             'feedback' (ACK/NACK)
          Outputs: 
             'out' (payload), 
             'dest_addr' (selected address)
          """
          def __init__(self, bg_image=""):
              gr.basic_block.__init__(
                  self,
                  name="Messenger GUI",
                  in_sig=None,
                  out_sig=None,
              )

              # Registers
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("dest_addr"))
              
              self.message_port_register_in(pmt.intern("in"))      # Incoming PDU
              self.message_port_register_in(pmt.intern("feedback")) # ACKs

              self.set_msg_handler(pmt.intern("feedback"), self._process_feedback_msg)
              self.set_msg_handler(pmt.intern("in"), self._process_incoming_pdu)

              self.qapp = QtWidgets.QApplication.instance()
              if not self.qapp:
                  self.qapp = QtWidgets.QApplication(sys.argv)

              self.signaler = GuiSignaler()
              self.gui_window = MessengerWindow(bg_image=bg_image)
              
              # Connections
              self.signaler.feedback_signal.connect(self.gui_window.handle_feedback)
              self.signaler.receive_signal.connect(self.gui_window.handle_received_msg)
              
              self.gui_window.send_to_gr_signal.connect(self._send_payload)
              self.gui_window.addr_selected_signal.connect(self._send_dest_addr)

              self.gui_window.show()

          def _process_feedback_msg(self, msg):
              try:
                  if pmt.is_symbol(msg):
                      s = pmt.symbol_to_string(msg)
                      self.signaler.feedback_signal.emit(s)
              except Exception:
                  pass

          def _process_incoming_pdu(self, msg):
              """
              Expects PDU: Pair(Meta, u8vector).
              Byte 0 = Sender Address.
              Bytes 1+ = Text.
              """
              try:
                  if not pmt.is_pair(msg): return
                  vec = pmt.cdr(msg)
                  if not pmt.is_u8vector(vec): return
                  
                  data = bytearray(pmt.u8vector_elements(vec))
                  if len(data) < 1: return
                  
                  sender_addr = data[0] # Byte 0
                  payload = data[1:]    # Remaining bytes
                  
                  text = payload.decode("utf-8", errors="ignore")
                  
                  # Emit to GUI
                  self.signaler.receive_signal.emit(sender_addr, text)
                  
              except Exception as e:
                  print(f"Error processing input PDU: {e}")

          def _send_payload(self, text_msg):
              self.message_port_pub(pmt.intern("out"), pmt.string_to_symbol(text_msg))

          def _send_dest_addr(self, addr_str):
              self.message_port_pub(pmt.intern("dest_addr"), pmt.string_to_symbol(addr_str))
    bg_image: '''/home/vboxuser/Downloads/tx.jpg'''
  states: {}
- name: epy_block_2_0_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport threading\nimport pmt\nfrom gnuradio import gr\nimport time\n\nclass pdu_text_gui(gr.basic_block):\n    \"\"\"\n    Custom block: QT GUI Message Entry -> PDU sender with Go-Back-N ARQ.\n    - Splits text into packets (2 bytes: [address, seq_id] + payload)\n    - Sends packets in a sliding window\n    - Waits for ACKs [0xAA, seq_id]\n    - On timeout, retransmits all unACKed packets in window\n    - After full message, sends END packet [address, seq_id] (no payload)\n    - Sends feedback to GUI when END ACK is received\n    - Sends feedback if retry limit is exceeded\n    - Next message starts from the first unacknowledged sequence number\n    \"\"\"\n\n    def __init__(self, wait_time=2.0, pkt_size=32, address=0x01, retry_limit=100, window_size=4):\n        gr.basic_block.__init__(\n            self,\n            name=\"GUI Text to PDU with Go-Back-N ARQ\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        # Parameters\n        self._timeout = float(wait_time)\n        self._pkt_size = int(pkt_size)\n        self._address = int(address) & 0xFF\n        self._retry_limit = int(retry_limit)\n        self._window_size = int(window_size)\n\n        # Sequence control\n        self._seq_id = 1          # next sequence ID to start with\n        self._last_ack_seq = 0    # last acknowledged ID\n        self._has_acks = False    # tracks if any ACKs have been received\n\n        # Message ports\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_out(pmt.intern(\"feedback\"))  # feedback port for GUI\n\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_in(pmt.intern(\"ack_in\"))\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._process_text)\n        self.set_msg_handler(pmt.intern(\"ack_in\"), self._process_ack)\n\n        # Thread + synchronization\n        self._thread = None\n        self._stop_event = threading.Event()\n        self._lock = threading.Lock()\n\n        # Buffers\n        self._text_data = b\"\"\n        self._packets = []\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n        self._end_seq_id = 0\n\n    # ---------------------------\n    # Message handler from GUI\n    # ---------------------------\n    def _process_text(self, msg):\n        try:\n            if pmt.is_symbol(msg):\n                text_str = pmt.symbol_to_string(msg)\n            elif pmt.is_string(msg):\n                text_str = pmt.string_to_string(msg)\n            else:\n                print(\"[pdu_text_gui] Invalid PMT message type\")\n                return\n\n            self._text_data = text_str.encode(\"utf-8\")\n\n            # Start sending in a separate thread\n            if self._thread is None or not self._thread.is_alive():\n                self._stop_event.clear()\n                self._thread = threading.Thread(target=self._run)\n                self._thread.daemon = True\n                self._thread.start()\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] Error processing text: {e}\")\n\n    # ---------------------------\n    # Sending loop (Go-Back-N)\n    # ---------------------------\n    def _run(self):\n        raw = self._text_data\n        step = self._pkt_size - 2\n        blocks = [raw[i:i+step] for i in range(0, len(raw), step)]\n\n        # Determine starting seq_id\n        if self._has_acks:\n            # continue from the next unACKed sequence\n            self._seq_id = (self._last_ack_seq + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n        else:\n            self._seq_id = 1\n\n        print(f\"[pdu_text_gui] Starting new message at seq=0x{self._seq_id:02X}\")\n\n        # Build packets\n        self._packets = []\n        for block in blocks:\n            packet = bytes([self._address, self._seq_id]) + block\n            self._packets.append((self._seq_id, packet))\n            self._seq_id = (self._seq_id + 1) & 0xFF\n            if self._seq_id == 0:\n                self._seq_id = 1\n\n        # Add END packet\n        end_packet = bytes([self._address, self._seq_id])\n        self._packets.append((self._seq_id, end_packet))\n        self._end_seq_id = self._seq_id\n        print(f\"[pdu_text_gui] End packet prepared (id=0x{self._seq_id:02X})\")\n\n        self._seq_id = (self._seq_id + 1) & 0xFF\n        if self._seq_id == 0:\n            self._seq_id = 1\n\n        # Reset window variables\n        self._base = 0\n        self._next_to_send = 0\n        self._attempts = 0\n\n        while self._base < len(self._packets) and not self._stop_event.is_set():\n            with self._lock:\n                # Send up to window_size packets\n                while self._next_to_send < self._base + self._window_size and self._next_to_send < len(self._packets):\n                    seq_id, packet = self._packets[self._next_to_send]\n                    vec = pmt.init_u8vector(len(packet), list(packet))\n                    pdu = pmt.cons(pmt.PMT_NIL, vec)\n                    self.message_port_pub(pmt.intern(\"out\"), pdu)\n                    if len(packet) > 2:\n                        print(f\"[pdu_text_gui] Packet id=0x{seq_id:02X} sent\")\n                    else:\n                        print(f\"[pdu_text_gui] END packet id=0x{seq_id:02X} sent\")\n                    self._next_to_send += 1\n\n            # Wait for ACK\n            time.sleep(self._timeout)\n\n            with self._lock:\n                if self._base < self._next_to_send:\n                    self._attempts += 1\n                    if self._attempts >= self._retry_limit:\n                        print(\"[pdu_text_gui] Failed: retry limit exceeded\")\n                        self.message_port_pub(pmt.intern(\"feedback\"), pmt.intern(\"RETRY_LIMIT_EXCEEDED\"))\n                        self._stop_event.set()\n                        break\n\n                    print(\"[pdu_text_gui] Timeout: retransmitting window\")\n                    for i in range(self._base, self._next_to_send):\n                        seq_id, packet = self._packets[i]\n                        vec = pmt.init_u8vector(len(packet), list(packet))\n                        pdu = pmt.cons(pmt.PMT_NIL, vec)\n                        self.message_port_pub(pmt.intern(\"out\"), pdu)\n                        if len(packet) > 2:\n                            print(f\"[pdu_text_gui] Retransmit id=0x{seq_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] Retransmit END id=0x{seq_id:02X}\")\n\n    # ---------------------------\n    # ACK handler\n    # ---------------------------\n    def _process_ack(self, msg):\n        try:\n            payload = pmt.cdr(msg)\n            if not pmt.is_u8vector(payload):\n                return\n\n            arr = bytearray(pmt.u8vector_elements(payload))\n            if len(arr) < 2 or arr[0] != 0xAA:\n                return\n\n            ack_id = arr[1]\n            with self._lock:\n                # slide window if ACK is valid\n                for i in range(self._base, self._next_to_send):\n                    seq_id, _ = self._packets[i]\n                    if seq_id == ack_id:\n                        self._has_acks = True\n                        self._last_ack_seq = ack_id  # save last ACKed seq\n                        if len(self._packets[i][1]) > 2:\n                            print(f\"[pdu_text_gui] ACK received for id=0x{ack_id:02X}\")\n                        else:\n                            print(f\"[pdu_text_gui] ACK received for END id=0x{ack_id:02X}\")\n                            self.message_port_pub(pmt.intern(\"feedback\"), pmt.intern(\"END_ACK_RECEIVED\"))\n                        self._base = i + 1\n                        self._attempts = 0\n                        break\n\n        except Exception as e:\n            print(f\"[pdu_text_gui] Error processing ACK: {e}\")\n\n"
    address: '50'
    pkt_size: '32'
    retry_limit: '100'
    wait_time: '0.1'
    window_size: '7'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '10'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-

      import pmt
      from gnuradio import gr

      class address_check(gr.basic_block):
          """
          Block to check address and strip it if matches
          """
          def __init__(self, my_address=0x01):
              gr.basic_block.__init__(
                  self,
                  name="address_check",
                  in_sig=[],
                  out_sig=[]
              )
              self.my_address = my_address
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  data = bytearray(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data[0] == self.my_address:
                      # strip address
                      payload = data[1:]
                      out_msg = pmt.cons(meta, pmt.init_u8vector(len(payload), payload))
                      self.message_port_pub(pmt.intern("out"), out_msg)
                  # else drop silently
    my_address: '50'
  states: {}
- name: epy_block_3_1
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nfrom gnuradio import gr\nfrom PyQt5 import QtWidgets, QtCore, QtGui\nimport sys\nimport pmt\nfrom datetime import datetime  # For timestamps\n\nclass WallpaperScrollArea(QtWidgets.QScrollArea):\n    def __init__(self, bg_image=\"\", parent=None):\n        super().__init__(parent)\n        self.setWidgetResizable(True)\n        self.setHorizontalScrollBarPolicy(QtCore.Qt.ScrollBarAlwaysOff)\n        self.bg_pixmap = QtGui.QPixmap(bg_image) if bg_image else None\n\n    def paintEvent(self, event):\n        if self.bg_pixmap:\n            painter = QtGui.QPainter(self.viewport())\n            painter.drawPixmap(self.viewport().rect(), self.bg_pixmap)\n        super().paintEvent(event)\n\nclass multi_sender_gui(gr.basic_block):\n    \"\"\"\n    Multi-sender PDU GUI with dark bluish-grey left panel\n    and Messenger-style scalable chat bubbles with timestamps.\n    \"\"\"\n\n    def __init__(self, bg_image=\"\"):\n        gr.basic_block.__init__(self,\n            name=\"Multi-Sender PDU Viewer\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.bg_image = bg_image\n        self.msg_queue = []\n        self.sender_msgs = {}\n        self.sender_buttons = {}\n        self.current_sender = None\n        self.unread = set()\n\n        # PDU input\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_pdu)\n\n        # Ensure QApplication exists\n        self.app = QtWidgets.QApplication.instance()\n        if self.app is None:\n            self.app = QtWidgets.QApplication(sys.argv)\n\n        # Initialize GUI\n        self.init_gui()\n\n    def init_gui(self):\n        self.qt_widget = QtWidgets.QWidget()\n        self.qt_widget.setWindowTitle(\"Multi-Sender PDU Viewer\")\n        self.qt_widget.resize(800, 500)\n\n        main_layout = QtWidgets.QHBoxLayout()\n        main_layout.setContentsMargins(0,0,0,0)\n        main_layout.setSpacing(0)\n        self.qt_widget.setLayout(main_layout)\n\n        # Left: sender panel\n        self.sender_layout_widget = QtWidgets.QWidget()\n        self.sender_layout_widget.setStyleSheet(\"background-color: #1B263B;\")\n        self.sender_layout = QtWidgets.QVBoxLayout()\n        self.sender_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.sender_layout_widget.setLayout(self.sender_layout)\n        main_layout.addWidget(self.sender_layout_widget)\n        self.sender_layout_widget.setFixedWidth(150)\n\n        # Right: chat with wallpaper\n        self.scroll_area = WallpaperScrollArea(bg_image=self.bg_image)\n        self.scroll_area.setWidgetResizable(True)\n        self.chat_container = QtWidgets.QWidget()\n        self.chat_layout = QtWidgets.QVBoxLayout()\n        self.chat_layout.setAlignment(QtCore.Qt.AlignTop)\n        self.chat_container.setLayout(self.chat_layout)\n        self.chat_container.setStyleSheet(\"background: transparent;\")\n        self.scroll_area.setWidget(self.chat_container)\n        main_layout.addWidget(self.scroll_area, stretch=1)\n\n        # Show widget\n        self.qt_widget.show()\n\n        # Timer to process incoming messages\n        self.timer = QtCore.QTimer()\n        self.timer.timeout.connect(self.process_queue)\n        self.timer.start(50)\n\n    def handle_pdu(self, msg):\n        self.msg_queue.append(msg)\n\n    def process_queue(self):\n        while self.msg_queue:\n            msg = self.msg_queue.pop(0)\n            self.store_message(msg)\n\n    def store_message(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 1:\n            return\n\n        sender_bytes = data[0:1]\n        sender = f\"Node {sender_bytes[0]:02X}\"\n        payload = data[1:]\n\n        try:\n            text = payload.decode(\"utf-8\", errors=\"ignore\")\n        except Exception:\n            text = \"<decode error>\"\n\n        # Store timestamp along with the text (HH:MM)\n        timestamp = datetime.now().strftime(\"%H:%M\")\n\n        if sender not in self.sender_msgs:\n            self.sender_msgs[sender] = []\n            self.add_sender_slot(sender)\n        self.sender_msgs[sender].append((text, timestamp))  # store as tuple\n\n        if self.current_sender != sender:\n            self.unread.add(sender)\n            self.update_sender_slot(sender)\n\n        if self.current_sender == sender or self.current_sender is None:\n            self.display_sender_messages(sender)\n\n    def add_sender_slot(self, sender):\n        slot_widget = QtWidgets.QWidget()\n        slot_widget.setFixedHeight(50)\n        slot_widget.setStyleSheet(\"\"\"\n            background-color: #2C3E50;\n            border-radius: 8px;\n        \"\"\")\n        layout = QtWidgets.QHBoxLayout()\n        layout.setContentsMargins(10,0,10,0)\n        slot_widget.setLayout(layout)\n\n        name_label = QtWidgets.QLabel(sender)\n        name_label.setStyleSheet(\"color: white; font-weight: bold;\")\n        layout.addWidget(name_label, alignment=QtCore.Qt.AlignLeft)\n\n        dot_label = QtWidgets.QLabel(\"\\u25CF\")\n        dot_label.setStyleSheet(\"color: yellow; font-weight: bold;\")\n        dot_label.setVisible(False)\n        layout.addWidget(dot_label, alignment=QtCore.Qt.AlignRight)\n\n        slot_widget.mousePressEvent = lambda e, s=sender: self.display_sender_messages(s)\n\n        self.sender_buttons[sender] = {'widget': slot_widget, 'dot': dot_label, 'name': name_label}\n        self.sender_layout.addWidget(slot_widget)\n\n    def update_sender_slot(self, sender):\n        btn_info = self.sender_buttons.get(sender)\n        if btn_info:\n            btn_info['dot'].setVisible(sender in self.unread)\n\n    def display_sender_messages(self, sender):\n        self.current_sender = sender\n        if sender in self.unread:\n            self.unread.remove(sender)\n            self.update_sender_slot(sender)\n\n        # Clear chat layout\n        for i in reversed(range(self.chat_layout.count())):\n            w = self.chat_layout.takeAt(i).widget()\n            if w:\n                w.deleteLater()\n\n        msgs = self.sender_msgs.get(sender, [])\n        for text, timestamp in msgs:  # unpack tuple\n            self.add_bubble(text, timestamp)  # pass timestamp\n\n        QtCore.QTimer.singleShot(50, lambda: self.scroll_area.verticalScrollBar().setValue(\n            self.scroll_area.verticalScrollBar().maximum()\n        ))\n\n    def add_bubble(self, text, timestamp):\n        # Chat bubble\n        bubble = QtWidgets.QLabel(text)\n        bubble.setWordWrap(True)\n        bubble.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #2196F3;\n                color: white;\n                border-radius: 15px;\n                padding: 20px 30px;\n                font-size: 32px;\n            }\n        \"\"\")\n        bubble.setSizePolicy(QtWidgets.QSizePolicy.Expanding, QtWidgets.QSizePolicy.Minimum)\n        bubble.setMaximumWidth(500)\n        bubble.setMinimumHeight(bubble.sizeHint().height())\n\n        # Shadow effect\n        effect = QtWidgets.QGraphicsDropShadowEffect()\n        effect.setBlurRadius(6)\n        effect.setXOffset(2)\n        effect.setYOffset(2)\n        effect.setColor(QtGui.QColor(0,0,0,100))\n        bubble.setGraphicsEffect(effect)\n\n        # Timestamp with small green \"pill\"\n        ts_label = QtWidgets.QLabel(timestamp)  # use stored timestamp (HH:MM)\n        ts_label.setStyleSheet(\"\"\"\n            QLabel {\n                background-color: #4CAF50;  /* green background */\n                color: white;\n                font-size: 18px;\n                border-radius: 8px;\n                padding: 2px 6px;\n            }\n        \"\"\")\n        ts_label.setAlignment(QtCore.Qt.AlignRight)\n        ts_label.setSizePolicy(QtWidgets.QSizePolicy.Fixed, QtWidgets.QSizePolicy.Fixed)\n\n        # Container for bubble + timestamp\n        container = QtWidgets.QWidget()\n        layout = QtWidgets.QVBoxLayout()\n        layout.setAlignment(QtCore.Qt.AlignLeft)\n        layout.setContentsMargins(0,0,0,0)\n        layout.addWidget(bubble)\n        layout.addWidget(ts_label, alignment=QtCore.Qt.AlignRight)\n        container.setLayout(layout)\n\n        self.chat_layout.addWidget(container, alignment=QtCore.Qt.AlignLeft)\n\n# Run GUI for standalone testing\nif __name__ == \"__main__\":\n    app = QtWidgets.QApplication(sys.argv)\n    gui = multi_sender_gui()\n    sys.exit(app.app.exec_())\n\n"
    bg_image: '''/home/vboxuser/Downloads/Networks_Telecommunications.jpg'''
  states: {state: disabled}
- name: epy_block_4_0
  id: epy_block
  parameters:
    _source_code: "#!/usr/bin/env python3\n# -*- coding: utf-8 -*-\n\nimport pmt\nimport zlib\nimport time\nfrom gnuradio import gr\n\nclass crc_forwarder(gr.basic_block):\n    \"\"\"\n    CRC32 Checker + Dedup + Forwarder (Message Reassembler)\n    - Input : [sender_addr | seq_id | payload | crc32]\n    - Output: [sender_addr | full_message] (only when END marker)\n    - END marker = valid packet with empty payload\n    - Adds parameter 'retry_limit' to retransmit ACKs multiple times\n    \"\"\"\n\n    def __init__(self, retry_limit=1):\n        gr.basic_block.__init__(\n            self,\n            name=\"CRC32 Dedup + Forwarder\",\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.retry_limit = max(1, int(retry_limit))  # ensure >= 1\n\n        self.received_ids = set()\n        self.buffers = {}\n\n        # Ports\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.message_port_register_out(pmt.intern(\"ack_out\"))\n\n        self.set_msg_handler(pmt.intern(\"in\"), self._handle_msg)\n\n        print(f\"[CRC32] Receiver initialized (retry_limit={self.retry_limit})\")\n\n    def _send_ack(self, ack_data):\n        \"\"\"Send ACK multiple times based on retry_limit.\"\"\"\n        ack_vec = pmt.init_u8vector(len(ack_data), list(ack_data))\n        ack_pdu = pmt.cons(pmt.PMT_NIL, ack_vec)\n\n        for i in range(self.retry_limit):\n            self.message_port_pub(pmt.intern(\"ack_out\"), ack_pdu)\n            print(f\"[ACK] Retransmit {i+1}/{self.retry_limit}\")\n            time.sleep(0.01)  # short delay (optional)\n\n    def _handle_msg(self, msg):\n        if not pmt.is_pair(msg):\n            return\n        vec = pmt.cdr(msg)\n        if not pmt.is_u8vector(vec):\n            return\n\n        data = bytearray(pmt.u8vector_elements(vec))\n        if len(data) < 6:\n            print(\"[CRC32] Frame too short\")\n            return\n\n        sender_addr = data[0]\n        pkt_id = data[1]\n        payload = data[2:-4]\n        recv_crc = int.from_bytes(data[-4:], \"big\")\n\n        calc_crc = zlib.crc32(bytes([sender_addr, pkt_id]) + payload) & 0xFFFFFFFF\n\n        if calc_crc != recv_crc:\n            print(f\"[CRC32] FAIL (Addr=0x{sender_addr:02X}, ID={pkt_id})\")\n            return\n\n        print(f\"[CRC32] OK (Addr=0x{sender_addr:02X}, ID={pkt_id})\")\n\n        # --- Build ACK ---\n        ack_data = bytearray([sender_addr, 0xAA, pkt_id])\n        ack_crc = zlib.crc32(ack_data) & 0xFFFFFFFF\n        ack_data += ack_crc.to_bytes(4, 'big')\n\n        print(f\"[ACK] Sending ACK with retry limit {self.retry_limit}\")\n        self._send_ack(ack_data)\n\n        # Dedup\n        if (sender_addr, pkt_id) in self.received_ids:\n            print(f\"[Forward] Duplicate packet ID={pkt_id}, ignored\")\n            return\n        self.received_ids.add((sender_addr, pkt_id))\n\n        # END MARKER\n        if len(payload) == 0:\n            if sender_addr in self.buffers and self.buffers[sender_addr]:\n                full_payload = b''.join(self.buffers[sender_addr])\n                forward_bytes = bytes([sender_addr]) + full_payload\n\n                out_vec = pmt.init_u8vector(len(forward_bytes), list(forward_bytes))\n                out_msg = pmt.cons(pmt.PMT_NIL, out_vec)\n                self.message_port_pub(pmt.intern(\"out\"), out_msg)\n\n                print(f\"[Forward] Reassembled {len(full_payload)} bytes\")\n\n            else:\n                print(f\"[Forward] END marker received but no data\")\n\n            self.buffers[sender_addr] = []\n            return\n\n        # Buffering\n        if sender_addr not in self.buffers:\n            self.buffers[sender_addr] = []\n\n        self.buffers[sender_addr].append(payload)\n        total_len = sum(len(p) for p in self.buffers[sender_addr])\n        print(f\"[Buffer] Addr 0x{sender_addr:02X}, ID {pkt_id}, +{len(payload)} bytes (total {total_len})\")\n\n"
    retry_limit: '2'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Cryptodome.Cipher import AES
      from Cryptodome.Util.Padding import pad

      class aes_encrypt(gr.basic_block):
          """
          AES Encryption Block
          - Encrypts PDUs using AES-128-CBC
          - Key & IV fixed for demo (replace with secure exchange in real systems)
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Encrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  enc_data = cipher.encrypt(pad(data, AES.block_size))

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(enc_data), list(enc_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import pad

      class aes_encrypt(gr.basic_block):
          """
          AES Encryption Block
          - Encrypts PDUs using AES-128-CBC
          - Key & IV fixed for demo (replace with secure exchange in real systems)
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Encrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  enc_data = cipher.encrypt(pad(data, AES.block_size))

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(enc_data), list(enc_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Cryptodome.Cipher import AES
      from Cryptodome.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: epy_block_6_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      import pmt
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util.Padding import unpad

      class aes_decrypt(gr.basic_block):
          """
          AES Decryption Block
          - Decrypts PDUs using AES-128-CBC
          - Must use the same Key & IV as the Encrypt block
          """

          def __init__(self, key=b"1234567890abcdef", iv=b"abcdef1234567890"):
              gr.basic_block.__init__(
                  self,
                  name="AES Decrypt",
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

              self.key = key
              self.iv = iv

          def handle_msg(self, msg_pmt):
              if pmt.is_pair(msg_pmt):
                  meta = pmt.car(msg_pmt)
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg_pmt)))

                  cipher = AES.new(self.key, AES.MODE_CBC, self.iv)
                  dec_data = unpad(cipher.decrypt(data), AES.block_size)

                  out_pmt = pmt.cons(meta, pmt.init_u8vector(len(dec_data), list(dec_data)))
                  self.message_port_pub(pmt.intern("out"), out_pmt)
    iv: b"abcdef1234567890"
    key: b"1234567890abcd30"
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,1,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Frequency Spectrum of Tx
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    comment: Frequency Spectrum of Tx ACK
    fc: '0'
    fftsize: '1024'
    name: TX - Spectrum of ACK
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: RX-SPECTRUM
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    name: RX-SPECTRUM of ACK
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: txgain
    samp_rate: samp_rate_blade*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 2.4e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '10000'
    center_freq: 1.2e9
    gain: '30.0'
    samp_rate: samp_rate*2
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: gui
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ACK
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: gui
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [blocks_repack_bits_bb_1, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_1_0, '0', virtual_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [channels_channel_model_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_crc_append_0, out, epy_block_0, in]
- [digital_crc_append_0, out, epy_block_5, in]
- [digital_crc_append_0, out, epy_block_5_0, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_protocol_formatter_async_0, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0_0, header, pdu_pdu_to_tagged_stream_0_1, pdus]
- [digital_protocol_formatter_async_0_0, payload, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_linear_equalizer_0_0_0, '0']
- [epy_block_0, out, digital_protocol_formatter_async_0, in]
- [epy_block_0_1_0, dest_addr, epy_block_0, addr_in]
- [epy_block_0_1_0, out, epy_block_2_0_0, in]
- [epy_block_2_0_0, feedback, epy_block_0_1_0, feedback]
- [epy_block_2_0_0, out, digital_crc_append_0, in]
- [epy_block_3, out, epy_block_4_0, in]
- [epy_block_3, out, epy_block_6, in]
- [epy_block_3, out, epy_block_6_0, in]
- [epy_block_3_0, out, epy_block_2_0_0, ack_in]
- [epy_block_4_0, ack_out, digital_protocol_formatter_async_0_0, in]
- [epy_block_4_0, out, epy_block_3_1, in]
- [epy_block_4_0, out, virtual_sink_2, '0']
- [epy_block_6, out, epy_block_4_0, in]
- [epy_block_6_0, out, epy_block_4_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_3, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, epy_block_3_0, in]
- [soapy_bladerf_source_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_1, '0']
- [soapy_bladerf_source_0_0, '0', digital_symbol_sync_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_1_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [virtual_source_2, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [virtual_source_3, '0', epy_block_0_1_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
